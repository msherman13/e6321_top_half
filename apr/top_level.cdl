$ Spice netlist generated by v2lvs
$ v2010.3_37.26    Mon Oct 4 16:21:17 PDT 2010
.INCLUDE "/tools2/courses/ee6321/share/ibm13rflpvt/lvs_netlist/ibm13rflpvt.cdl"

.SUBCKT top_level clk reset acc_fft_get acc_fft_put acc_fir_get acc_fir_put
+ acc_fft_data_out[31] acc_fft_data_out[30] acc_fft_data_out[29]
+ acc_fft_data_out[28] acc_fft_data_out[27] acc_fft_data_out[26]
+ acc_fft_data_out[25] acc_fft_data_out[24] acc_fft_data_out[23]
+ acc_fft_data_out[22] acc_fft_data_out[21] acc_fft_data_out[20]
+ acc_fft_data_out[19] acc_fft_data_out[18] acc_fft_data_out[17]
+ acc_fft_data_out[16] acc_fft_data_out[15] acc_fft_data_out[14]
+ acc_fft_data_out[13] acc_fft_data_out[12] acc_fft_data_out[11]
+ acc_fft_data_out[10] acc_fft_data_out[9] acc_fft_data_out[8]
+ acc_fft_data_out[7] acc_fft_data_out[6] acc_fft_data_out[5]
+ acc_fft_data_out[4] acc_fft_data_out[3] acc_fft_data_out[2]
+ acc_fft_data_out[1] acc_fft_data_out[0] acc_fft_data_in[31]
+ acc_fft_data_in[30] acc_fft_data_in[29] acc_fft_data_in[28]
+ acc_fft_data_in[27] acc_fft_data_in[26] acc_fft_data_in[25]
+ acc_fft_data_in[24] acc_fft_data_in[23] acc_fft_data_in[22]
+ acc_fft_data_in[21] acc_fft_data_in[20] acc_fft_data_in[19]
+ acc_fft_data_in[18] acc_fft_data_in[17] acc_fft_data_in[16]
+ acc_fft_data_in[15] acc_fft_data_in[14] acc_fft_data_in[13]
+ acc_fft_data_in[12] acc_fft_data_in[11] acc_fft_data_in[10]
+ acc_fft_data_in[9] acc_fft_data_in[8] acc_fft_data_in[7] acc_fft_data_in[6]
+ acc_fft_data_in[5] acc_fft_data_in[4] acc_fft_data_in[3] acc_fft_data_in[2]
+ acc_fft_data_in[1] acc_fft_data_in[0] acc_fir_data_out[31]
+ acc_fir_data_out[30] acc_fir_data_out[29] acc_fir_data_out[28]
+ acc_fir_data_out[27] acc_fir_data_out[26] acc_fir_data_out[25]
+ acc_fir_data_out[24] acc_fir_data_out[23] acc_fir_data_out[22]
+ acc_fir_data_out[21] acc_fir_data_out[20] acc_fir_data_out[19]
+ acc_fir_data_out[18] acc_fir_data_out[17] acc_fir_data_out[16]
+ acc_fir_data_out[15] acc_fir_data_out[14] acc_fir_data_out[13]
+ acc_fir_data_out[12] acc_fir_data_out[11] acc_fir_data_out[10]
+ acc_fir_data_out[9] acc_fir_data_out[8] acc_fir_data_out[7]
+ acc_fir_data_out[6] acc_fir_data_out[5] acc_fir_data_out[4]
+ acc_fir_data_out[3] acc_fir_data_out[2] acc_fir_data_out[1]
+ acc_fir_data_out[0] acc_fir_data_in[31] acc_fir_data_in[30]
+ acc_fir_data_in[29] acc_fir_data_in[28] acc_fir_data_in[27]
+ acc_fir_data_in[26] acc_fir_data_in[25] acc_fir_data_in[24]
+ acc_fir_data_in[23] acc_fir_data_in[22] acc_fir_data_in[21]
+ acc_fir_data_in[20] acc_fir_data_in[19] acc_fir_data_in[18]
+ acc_fir_data_in[17] acc_fir_data_in[16] acc_fir_data_in[15]
+ acc_fir_data_in[14] acc_fir_data_in[13] acc_fir_data_in[12]
+ acc_fir_data_in[11] acc_fir_data_in[10] acc_fir_data_in[9] acc_fir_data_in[8]
+ acc_fir_data_in[7] acc_fir_data_in[6] acc_fir_data_in[5] acc_fir_data_in[4]
+ acc_fir_data_in[3] acc_fir_data_in[2] acc_fir_data_in[1] acc_fir_data_in[0]
+ fft_enable fir_enable to_fft_empty from_fft_full to_fir_empty from_fir_full
+ ram_read_enable ram_write_enable addr[31] addr[30] addr[29] addr[28] addr[27]
+ addr[26] addr[25] addr[24] addr[23] addr[22] addr[21] addr[20] addr[19]
+ addr[18] addr[17] addr[16] addr[15] addr[14] addr[13] addr[12] addr[11]
+ addr[10] addr[9] addr[8] addr[7] addr[6] addr[5] addr[4] addr[3] addr[2]
+ addr[1] addr[0] data_bus[31] data_bus[30] data_bus[29] data_bus[28]
+ data_bus[27] data_bus[26] data_bus[25] data_bus[24] data_bus[23] data_bus[22]
+ data_bus[21] data_bus[20] data_bus[19] data_bus[18] data_bus[17] data_bus[16]
+ data_bus[15] data_bus[14] data_bus[13] data_bus[12] data_bus[11] data_bus[10]
+ data_bus[9] data_bus[8] data_bus[7] data_bus[6] data_bus[5] data_bus[4]
+ data_bus[3] data_bus[2] data_bus[1] data_bus[0]
Xclk__L1_I0 clk__L1_N0 clk CLKINVX16TS
XFE_OFC1825_n7107 FE_OFN1825_n7107 n7107 CLKBUFX2TS
XFE_OFC1824_router_addr_calc_fir_read_calc_count_5_
+ FE_OFN1824_router_addr_calc_fir_read_calc_count_5_
+ router_addr_calc_fir_read_calc_count[5] CLKBUFX2TS
XFE_OFC1823_n4643 FE_OFN1823_n4643 FE_OFN719_n4643 CLKBUFX2TS
XFE_OFC1822_n4643 FE_OFN1822_n4643 FE_OFN721_n4643 CLKBUFX2TS
XFE_OFC1821_acc_fft_data_in_28_ FE_OFN1821_acc_fft_data_in_28_
+ FE_OFN1819_acc_fft_data_in_28_ CLKINVX1TS
XFE_OFC1820_acc_fft_data_in_28_ FE_OFN1820_acc_fft_data_in_28_
+ FE_OFN1819_acc_fft_data_in_28_ CLKINVX1TS
XFE_OFC1819_acc_fft_data_in_28_ FE_OFN1819_acc_fft_data_in_28_
+ FE_OFN1469_acc_fft_data_in_28_ CLKINVX1TS
XFE_OFC1818_acc_fir_data_in_26_ FE_OFN1818_acc_fir_data_in_26_
+ FE_OFN1656_acc_fir_data_in_26_ CLKBUFX2TS
XFE_MDBC15_U5584 FE_MDBN15_ fft_data_in[7] BUFX2TS
XFE_OFC1817_acc_fir_data_in_0_ FE_OFN1817_acc_fir_data_in_0_
+ FE_OFN1815_acc_fir_data_in_0_ CLKINVX1TS
XFE_OFC1816_acc_fir_data_in_0_ FE_OFN1816_acc_fir_data_in_0_
+ FE_OFN1815_acc_fir_data_in_0_ CLKINVX1TS
XFE_OFC1815_acc_fir_data_in_0_ FE_OFN1815_acc_fir_data_in_0_
+ FE_OFN1813_acc_fir_data_in_0_ CLKINVX1TS
XFE_OFC1814_acc_fir_data_in_0_ FE_OFN1814_acc_fir_data_in_0_
+ FE_OFN1811_acc_fir_data_in_0_ CLKBUFX2TS
XFE_OFC1813_acc_fir_data_in_0_ FE_OFN1813_acc_fir_data_in_0_
+ FE_OFN1811_acc_fir_data_in_0_ CLKBUFX2TS
XFE_OFC1812_acc_fir_data_in_0_ FE_OFN1812_acc_fir_data_in_0_
+ FE_OFN1809_acc_fir_data_in_0_ CLKINVX1TS
XFE_OFC1811_acc_fir_data_in_0_ FE_OFN1811_acc_fir_data_in_0_
+ FE_OFN1809_acc_fir_data_in_0_ CLKINVX1TS
XFE_OFC1810_acc_fir_data_in_0_ FE_OFN1810_acc_fir_data_in_0_
+ FE_OFN1809_acc_fir_data_in_0_ CLKINVX1TS
XFE_OFC1809_acc_fir_data_in_0_ FE_OFN1809_acc_fir_data_in_0_
+ FE_OFN1808_acc_fir_data_in_0_ CLKINVX1TS
XFE_OFC1808_acc_fir_data_in_0_ FE_OFN1808_acc_fir_data_in_0_ acc_fir_data_in[0]
+ CLKBUFX2TS
XFE_OFC1807_acc_fir_data_in_1_ FE_OFN1807_acc_fir_data_in_1_
+ FE_OFN1805_acc_fir_data_in_1_ CLKBUFX2TS
XFE_OFC1806_acc_fir_data_in_1_ FE_OFN1806_acc_fir_data_in_1_
+ FE_OFN1805_acc_fir_data_in_1_ CLKBUFX2TS
XFE_OFC1805_acc_fir_data_in_1_ FE_OFN1805_acc_fir_data_in_1_
+ FE_OFN1803_acc_fir_data_in_1_ CLKBUFX2TS
XFE_OFC1804_acc_fir_data_in_1_ FE_OFN1804_acc_fir_data_in_1_
+ FE_OFN1803_acc_fir_data_in_1_ CLKBUFX2TS
XFE_OFC1803_acc_fir_data_in_1_ FE_OFN1803_acc_fir_data_in_1_
+ FE_OFN1802_acc_fir_data_in_1_ CLKBUFX2TS
XFE_OFC1802_acc_fir_data_in_1_ FE_OFN1802_acc_fir_data_in_1_ acc_fir_data_in[1]
+ CLKBUFX2TS
XFE_OFC1801_acc_fir_data_in_2_ FE_OFN1801_acc_fir_data_in_2_
+ FE_OFN1800_acc_fir_data_in_2_ CLKBUFX2TS
XFE_OFC1800_acc_fir_data_in_2_ FE_OFN1800_acc_fir_data_in_2_
+ FE_OFN1798_acc_fir_data_in_2_ CLKINVX1TS
XFE_OFC1799_acc_fir_data_in_2_ FE_OFN1799_acc_fir_data_in_2_
+ FE_OFN1798_acc_fir_data_in_2_ CLKINVX1TS
XFE_OFC1798_acc_fir_data_in_2_ FE_OFN1798_acc_fir_data_in_2_
+ FE_OFN1797_acc_fir_data_in_2_ CLKINVX1TS
XFE_OFC1797_acc_fir_data_in_2_ FE_OFN1797_acc_fir_data_in_2_
+ FE_OFN1796_acc_fir_data_in_2_ CLKBUFX2TS
XFE_OFC1796_acc_fir_data_in_2_ FE_OFN1796_acc_fir_data_in_2_
+ FE_OFN1795_acc_fir_data_in_2_ CLKBUFX2TS
XFE_OFC1795_acc_fir_data_in_2_ FE_OFN1795_acc_fir_data_in_2_ acc_fir_data_in[2]
+ CLKBUFX2TS
XFE_OFC1794_acc_fir_data_in_3_ FE_OFN1794_acc_fir_data_in_3_
+ FE_OFN1793_acc_fir_data_in_3_ CLKBUFX2TS
XFE_OFC1793_acc_fir_data_in_3_ FE_OFN1793_acc_fir_data_in_3_
+ FE_OFN1791_acc_fir_data_in_3_ CLKBUFX2TS
XFE_OFC1792_acc_fir_data_in_3_ FE_OFN1792_acc_fir_data_in_3_
+ FE_OFN1790_acc_fir_data_in_3_ CLKBUFX2TS
XFE_OFC1791_acc_fir_data_in_3_ FE_OFN1791_acc_fir_data_in_3_
+ FE_OFN1790_acc_fir_data_in_3_ CLKBUFX2TS
XFE_OFC1790_acc_fir_data_in_3_ FE_OFN1790_acc_fir_data_in_3_ acc_fir_data_in[3]
+ CLKBUFX2TS
XFE_OFC1789_acc_fir_data_in_4_ FE_OFN1789_acc_fir_data_in_4_
+ FE_OFN1787_acc_fir_data_in_4_ CLKBUFX2TS
XFE_OFC1788_acc_fir_data_in_4_ FE_OFN1788_acc_fir_data_in_4_
+ FE_OFN1786_acc_fir_data_in_4_ CLKBUFX2TS
XFE_OFC1787_acc_fir_data_in_4_ FE_OFN1787_acc_fir_data_in_4_
+ FE_OFN1784_acc_fir_data_in_4_ CLKBUFX2TS
XFE_OFC1786_acc_fir_data_in_4_ FE_OFN1786_acc_fir_data_in_4_
+ FE_OFN1785_acc_fir_data_in_4_ CLKBUFX2TS
XFE_OFC1785_acc_fir_data_in_4_ FE_OFN1785_acc_fir_data_in_4_
+ FE_OFN1783_acc_fir_data_in_4_ CLKINVX1TS
XFE_OFC1784_acc_fir_data_in_4_ FE_OFN1784_acc_fir_data_in_4_
+ FE_OFN1783_acc_fir_data_in_4_ CLKINVX1TS
XFE_OFC1783_acc_fir_data_in_4_ FE_OFN1783_acc_fir_data_in_4_ acc_fir_data_in[4]
+ CLKINVX1TS
XFE_OFC1782_acc_fir_data_in_5_ FE_OFN1782_acc_fir_data_in_5_
+ FE_OFN1781_acc_fir_data_in_5_ CLKBUFX2TS
XFE_OFC1781_acc_fir_data_in_5_ FE_OFN1781_acc_fir_data_in_5_
+ FE_OFN1780_acc_fir_data_in_5_ CLKBUFX2TS
XFE_OFC1780_acc_fir_data_in_5_ FE_OFN1780_acc_fir_data_in_5_
+ FE_OFN1778_acc_fir_data_in_5_ CLKBUFX2TS
XFE_OFC1779_acc_fir_data_in_5_ FE_OFN1779_acc_fir_data_in_5_
+ FE_OFN1778_acc_fir_data_in_5_ CLKBUFX2TS
XFE_OFC1778_acc_fir_data_in_5_ FE_OFN1778_acc_fir_data_in_5_
+ FE_OFN1777_acc_fir_data_in_5_ CLKBUFX2TS
XFE_OFC1777_acc_fir_data_in_5_ FE_OFN1777_acc_fir_data_in_5_ acc_fir_data_in[5]
+ CLKBUFX2TS
XFE_OFC1776_acc_fir_data_in_6_ FE_OFN1776_acc_fir_data_in_6_
+ FE_OFN1774_acc_fir_data_in_6_ CLKBUFX2TS
XFE_OFC1775_acc_fir_data_in_6_ FE_OFN1775_acc_fir_data_in_6_
+ FE_OFN1772_acc_fir_data_in_6_ CLKINVX1TS
XFE_OFC1774_acc_fir_data_in_6_ FE_OFN1774_acc_fir_data_in_6_
+ FE_OFN1772_acc_fir_data_in_6_ CLKINVX1TS
XFE_OFC1773_acc_fir_data_in_6_ FE_OFN1773_acc_fir_data_in_6_
+ FE_OFN1772_acc_fir_data_in_6_ CLKINVX1TS
XFE_OFC1772_acc_fir_data_in_6_ FE_OFN1772_acc_fir_data_in_6_
+ FE_OFN1770_acc_fir_data_in_6_ CLKINVX1TS
XFE_OFC1771_acc_fir_data_in_6_ FE_OFN1771_acc_fir_data_in_6_
+ FE_OFN1770_acc_fir_data_in_6_ CLKBUFX2TS
XFE_OFC1770_acc_fir_data_in_6_ FE_OFN1770_acc_fir_data_in_6_
+ FE_OFN1769_acc_fir_data_in_6_ CLKBUFX2TS
XFE_OFC1769_acc_fir_data_in_6_ FE_OFN1769_acc_fir_data_in_6_ acc_fir_data_in[6]
+ CLKBUFX2TS
XFE_OFC1768_acc_fir_data_in_7_ FE_OFN1768_acc_fir_data_in_7_
+ FE_OFN1765_acc_fir_data_in_7_ CLKBUFX2TS
XFE_OFC1767_acc_fir_data_in_7_ FE_OFN1767_acc_fir_data_in_7_
+ FE_OFN1766_acc_fir_data_in_7_ CLKBUFX2TS
XFE_OFC1766_acc_fir_data_in_7_ FE_OFN1766_acc_fir_data_in_7_
+ FE_OFN1764_acc_fir_data_in_7_ CLKINVX1TS
XFE_OFC1765_acc_fir_data_in_7_ FE_OFN1765_acc_fir_data_in_7_
+ FE_OFN1764_acc_fir_data_in_7_ CLKINVX1TS
XFE_OFC1764_acc_fir_data_in_7_ FE_OFN1764_acc_fir_data_in_7_
+ FE_OFN1763_acc_fir_data_in_7_ INVX3TS
XFE_OFC1763_acc_fir_data_in_7_ FE_OFN1763_acc_fir_data_in_7_
+ FE_OFN1762_acc_fir_data_in_7_ CLKBUFX2TS
XFE_OFC1762_acc_fir_data_in_7_ FE_OFN1762_acc_fir_data_in_7_ acc_fir_data_in[7]
+ CLKBUFX2TS
XFE_OFC1761_acc_fir_data_in_8_ FE_OFN1761_acc_fir_data_in_8_
+ FE_OFN1759_acc_fir_data_in_8_ CLKBUFX2TS
XFE_OFC1760_acc_fir_data_in_8_ FE_OFN1760_acc_fir_data_in_8_
+ FE_OFN1759_acc_fir_data_in_8_ CLKBUFX2TS
XFE_OFC1759_acc_fir_data_in_8_ FE_OFN1759_acc_fir_data_in_8_
+ FE_OFN1758_acc_fir_data_in_8_ CLKBUFX2TS
XFE_OFC1758_acc_fir_data_in_8_ FE_OFN1758_acc_fir_data_in_8_
+ FE_OFN1757_acc_fir_data_in_8_ CLKBUFX2TS
XFE_OFC1757_acc_fir_data_in_8_ FE_OFN1757_acc_fir_data_in_8_
+ FE_OFN1756_acc_fir_data_in_8_ CLKBUFX2TS
XFE_OFC1756_acc_fir_data_in_8_ FE_OFN1756_acc_fir_data_in_8_ acc_fir_data_in[8]
+ CLKBUFX2TS
XFE_OFC1755_acc_fir_data_in_9_ FE_OFN1755_acc_fir_data_in_9_
+ FE_OFN1753_acc_fir_data_in_9_ CLKBUFX2TS
XFE_OFC1754_acc_fir_data_in_9_ FE_OFN1754_acc_fir_data_in_9_
+ FE_OFN1752_acc_fir_data_in_9_ CLKBUFX2TS
XFE_OFC1753_acc_fir_data_in_9_ FE_OFN1753_acc_fir_data_in_9_
+ FE_OFN1751_acc_fir_data_in_9_ CLKBUFX2TS
XFE_OFC1752_acc_fir_data_in_9_ FE_OFN1752_acc_fir_data_in_9_
+ FE_OFN1751_acc_fir_data_in_9_ CLKBUFX2TS
XFE_OFC1751_acc_fir_data_in_9_ FE_OFN1751_acc_fir_data_in_9_ acc_fir_data_in[9]
+ CLKBUFX2TS
XFE_OFC1750_acc_fir_data_in_10_ FE_OFN1750_acc_fir_data_in_10_
+ FE_OFN1748_acc_fir_data_in_10_ CLKBUFX2TS
XFE_OFC1749_acc_fir_data_in_10_ FE_OFN1749_acc_fir_data_in_10_
+ FE_OFN1747_acc_fir_data_in_10_ CLKBUFX2TS
XFE_OFC1748_acc_fir_data_in_10_ FE_OFN1748_acc_fir_data_in_10_
+ FE_OFN1746_acc_fir_data_in_10_ CLKBUFX2TS
XFE_OFC1747_acc_fir_data_in_10_ FE_OFN1747_acc_fir_data_in_10_
+ FE_OFN1746_acc_fir_data_in_10_ CLKBUFX2TS
XFE_OFC1746_acc_fir_data_in_10_ FE_OFN1746_acc_fir_data_in_10_
+ acc_fir_data_in[10] CLKBUFX2TS
XFE_OFC1745_acc_fir_data_in_11_ FE_OFN1745_acc_fir_data_in_11_
+ FE_OFN1744_acc_fir_data_in_11_ CLKBUFX2TS
XFE_OFC1744_acc_fir_data_in_11_ FE_OFN1744_acc_fir_data_in_11_
+ FE_OFN1743_acc_fir_data_in_11_ CLKBUFX2TS
XFE_OFC1743_acc_fir_data_in_11_ FE_OFN1743_acc_fir_data_in_11_
+ FE_OFN1742_acc_fir_data_in_11_ CLKBUFX2TS
XFE_OFC1742_acc_fir_data_in_11_ FE_OFN1742_acc_fir_data_in_11_
+ FE_OFN1741_acc_fir_data_in_11_ CLKBUFX2TS
XFE_OFC1741_acc_fir_data_in_11_ FE_OFN1741_acc_fir_data_in_11_
+ acc_fir_data_in[11] CLKBUFX2TS
XFE_OFC1740_acc_fir_data_in_12_ FE_OFN1740_acc_fir_data_in_12_
+ FE_OFN1737_acc_fir_data_in_12_ CLKBUFX2TS
XFE_OFC1739_acc_fir_data_in_12_ FE_OFN1739_acc_fir_data_in_12_
+ FE_OFN1738_acc_fir_data_in_12_ CLKBUFX2TS
XFE_OFC1738_acc_fir_data_in_12_ FE_OFN1738_acc_fir_data_in_12_
+ FE_OFN1736_acc_fir_data_in_12_ CLKBUFX2TS
XFE_OFC1737_acc_fir_data_in_12_ FE_OFN1737_acc_fir_data_in_12_
+ FE_OFN1736_acc_fir_data_in_12_ CLKBUFX2TS
XFE_OFC1736_acc_fir_data_in_12_ FE_OFN1736_acc_fir_data_in_12_
+ acc_fir_data_in[12] CLKBUFX2TS
XFE_OFC1735_acc_fir_data_in_13_ FE_OFN1735_acc_fir_data_in_13_
+ FE_OFN1734_acc_fir_data_in_13_ CLKBUFX2TS
XFE_OFC1734_acc_fir_data_in_13_ FE_OFN1734_acc_fir_data_in_13_
+ FE_OFN1733_acc_fir_data_in_13_ CLKBUFX2TS
XFE_OFC1733_acc_fir_data_in_13_ FE_OFN1733_acc_fir_data_in_13_
+ FE_OFN1732_acc_fir_data_in_13_ CLKBUFX2TS
XFE_OFC1732_acc_fir_data_in_13_ FE_OFN1732_acc_fir_data_in_13_
+ FE_OFN1731_acc_fir_data_in_13_ CLKBUFX2TS
XFE_OFC1731_acc_fir_data_in_13_ FE_OFN1731_acc_fir_data_in_13_
+ acc_fir_data_in[13] CLKBUFX2TS
XFE_OFC1730_acc_fir_data_in_14_ FE_OFN1730_acc_fir_data_in_14_
+ FE_OFN1725_acc_fir_data_in_14_ CLKBUFX2TS
XFE_OFC1729_acc_fir_data_in_14_ FE_OFN1729_acc_fir_data_in_14_
+ FE_OFN1727_acc_fir_data_in_14_ CLKBUFX2TS
XFE_OFC1728_acc_fir_data_in_14_ FE_OFN1728_acc_fir_data_in_14_
+ FE_OFN1726_acc_fir_data_in_14_ CLKINVX1TS
XFE_OFC1727_acc_fir_data_in_14_ FE_OFN1727_acc_fir_data_in_14_
+ FE_OFN1726_acc_fir_data_in_14_ CLKINVX1TS
XFE_OFC1726_acc_fir_data_in_14_ FE_OFN1726_acc_fir_data_in_14_
+ FE_OFN1724_acc_fir_data_in_14_ CLKINVX1TS
XFE_OFC1725_acc_fir_data_in_14_ FE_OFN1725_acc_fir_data_in_14_
+ FE_OFN1724_acc_fir_data_in_14_ CLKBUFX2TS
XFE_OFC1724_acc_fir_data_in_14_ FE_OFN1724_acc_fir_data_in_14_
+ acc_fir_data_in[14] CLKBUFX2TS
XFE_OFC1723_acc_fir_data_in_15_ FE_OFN1723_acc_fir_data_in_15_
+ FE_OFN1720_acc_fir_data_in_15_ CLKBUFX2TS
XFE_OFC1722_acc_fir_data_in_15_ FE_OFN1722_acc_fir_data_in_15_
+ FE_OFN1721_acc_fir_data_in_15_ CLKBUFX2TS
XFE_OFC1721_acc_fir_data_in_15_ FE_OFN1721_acc_fir_data_in_15_
+ FE_OFN1719_acc_fir_data_in_15_ CLKBUFX2TS
XFE_OFC1720_acc_fir_data_in_15_ FE_OFN1720_acc_fir_data_in_15_
+ FE_OFN1719_acc_fir_data_in_15_ CLKBUFX2TS
XFE_OFC1719_acc_fir_data_in_15_ FE_OFN1719_acc_fir_data_in_15_
+ acc_fir_data_in[15] CLKBUFX2TS
XFE_OFC1718_acc_fir_data_in_16_ FE_OFN1718_acc_fir_data_in_16_
+ FE_OFN1717_acc_fir_data_in_16_ CLKBUFX2TS
XFE_OFC1717_acc_fir_data_in_16_ FE_OFN1717_acc_fir_data_in_16_
+ FE_OFN1715_acc_fir_data_in_16_ CLKBUFX2TS
XFE_OFC1716_acc_fir_data_in_16_ FE_OFN1716_acc_fir_data_in_16_
+ FE_OFN1714_acc_fir_data_in_16_ CLKINVX1TS
XFE_OFC1715_acc_fir_data_in_16_ FE_OFN1715_acc_fir_data_in_16_
+ FE_OFN1714_acc_fir_data_in_16_ CLKINVX1TS
XFE_OFC1714_acc_fir_data_in_16_ FE_OFN1714_acc_fir_data_in_16_
+ FE_OFN1713_acc_fir_data_in_16_ CLKINVX1TS
XFE_OFC1713_acc_fir_data_in_16_ FE_OFN1713_acc_fir_data_in_16_
+ FE_OFN1712_acc_fir_data_in_16_ CLKBUFX2TS
XFE_OFC1712_acc_fir_data_in_16_ FE_OFN1712_acc_fir_data_in_16_
+ acc_fir_data_in[16] CLKBUFX2TS
XFE_OFC1711_acc_fir_data_in_17_ FE_OFN1711_acc_fir_data_in_17_
+ FE_OFN1708_acc_fir_data_in_17_ CLKBUFX2TS
XFE_OFC1710_acc_fir_data_in_17_ FE_OFN1710_acc_fir_data_in_17_
+ FE_OFN1709_acc_fir_data_in_17_ CLKBUFX2TS
XFE_OFC1709_acc_fir_data_in_17_ FE_OFN1709_acc_fir_data_in_17_
+ FE_OFN1707_acc_fir_data_in_17_ CLKBUFX2TS
XFE_OFC1708_acc_fir_data_in_17_ FE_OFN1708_acc_fir_data_in_17_
+ FE_OFN1707_acc_fir_data_in_17_ CLKBUFX2TS
XFE_OFC1707_acc_fir_data_in_17_ FE_OFN1707_acc_fir_data_in_17_
+ acc_fir_data_in[17] CLKBUFX2TS
XFE_OFC1706_acc_fir_data_in_18_ FE_OFN1706_acc_fir_data_in_18_
+ FE_OFN1705_acc_fir_data_in_18_ CLKBUFX2TS
XFE_OFC1705_acc_fir_data_in_18_ FE_OFN1705_acc_fir_data_in_18_
+ FE_OFN1704_acc_fir_data_in_18_ CLKBUFX2TS
XFE_OFC1704_acc_fir_data_in_18_ FE_OFN1704_acc_fir_data_in_18_
+ FE_OFN1703_acc_fir_data_in_18_ CLKBUFX2TS
XFE_OFC1703_acc_fir_data_in_18_ FE_OFN1703_acc_fir_data_in_18_
+ FE_OFN1702_acc_fir_data_in_18_ CLKBUFX2TS
XFE_OFC1702_acc_fir_data_in_18_ FE_OFN1702_acc_fir_data_in_18_
+ acc_fir_data_in[18] CLKBUFX2TS
XFE_OFC1701_acc_fir_data_in_19_ FE_OFN1701_acc_fir_data_in_19_
+ FE_OFN1699_acc_fir_data_in_19_ CLKBUFX2TS
XFE_OFC1700_acc_fir_data_in_19_ FE_OFN1700_acc_fir_data_in_19_
+ FE_OFN1699_acc_fir_data_in_19_ CLKBUFX2TS
XFE_OFC1699_acc_fir_data_in_19_ FE_OFN1699_acc_fir_data_in_19_
+ FE_OFN1698_acc_fir_data_in_19_ CLKBUFX2TS
XFE_OFC1698_acc_fir_data_in_19_ FE_OFN1698_acc_fir_data_in_19_
+ FE_OFN1696_acc_fir_data_in_19_ CLKINVX1TS
XFE_OFC1697_acc_fir_data_in_19_ FE_OFN1697_acc_fir_data_in_19_
+ FE_OFN1696_acc_fir_data_in_19_ CLKINVX1TS
XFE_OFC1696_acc_fir_data_in_19_ FE_OFN1696_acc_fir_data_in_19_
+ FE_OFN1695_acc_fir_data_in_19_ CLKINVX1TS
XFE_OFC1695_acc_fir_data_in_19_ FE_OFN1695_acc_fir_data_in_19_
+ acc_fir_data_in[19] CLKBUFX2TS
XFE_OFC1694_acc_fir_data_in_20_ FE_OFN1694_acc_fir_data_in_20_
+ FE_OFN1692_acc_fir_data_in_20_ CLKBUFX2TS
XFE_OFC1693_acc_fir_data_in_20_ FE_OFN1693_acc_fir_data_in_20_
+ FE_OFN1691_acc_fir_data_in_20_ CLKBUFX2TS
XFE_OFC1692_acc_fir_data_in_20_ FE_OFN1692_acc_fir_data_in_20_
+ FE_OFN1691_acc_fir_data_in_20_ CLKBUFX2TS
XFE_OFC1691_acc_fir_data_in_20_ FE_OFN1691_acc_fir_data_in_20_
+ FE_OFN1690_acc_fir_data_in_20_ CLKBUFX2TS
XFE_OFC1690_acc_fir_data_in_20_ FE_OFN1690_acc_fir_data_in_20_
+ acc_fir_data_in[20] CLKBUFX2TS
XFE_OFC1689_acc_fir_data_in_21_ FE_OFN1689_acc_fir_data_in_21_
+ FE_OFN1687_acc_fir_data_in_21_ CLKBUFX2TS
XFE_OFC1688_acc_fir_data_in_21_ FE_OFN1688_acc_fir_data_in_21_
+ FE_OFN1686_acc_fir_data_in_21_ CLKINVX1TS
XFE_OFC1687_acc_fir_data_in_21_ FE_OFN1687_acc_fir_data_in_21_
+ FE_OFN1686_acc_fir_data_in_21_ CLKINVX1TS
XFE_OFC1686_acc_fir_data_in_21_ FE_OFN1686_acc_fir_data_in_21_
+ FE_OFN1685_acc_fir_data_in_21_ CLKINVX1TS
XFE_OFC1685_acc_fir_data_in_21_ FE_OFN1685_acc_fir_data_in_21_
+ FE_OFN1684_acc_fir_data_in_21_ CLKBUFX2TS
XFE_OFC1684_acc_fir_data_in_21_ FE_OFN1684_acc_fir_data_in_21_
+ FE_OFN1683_acc_fir_data_in_21_ CLKBUFX2TS
XFE_OFC1683_acc_fir_data_in_21_ FE_OFN1683_acc_fir_data_in_21_
+ acc_fir_data_in[21] CLKBUFX2TS
XFE_OFC1682_acc_fir_data_in_22_ FE_OFN1682_acc_fir_data_in_22_
+ FE_OFN1681_acc_fir_data_in_22_ CLKBUFX2TS
XFE_OFC1681_acc_fir_data_in_22_ FE_OFN1681_acc_fir_data_in_22_
+ FE_OFN1680_acc_fir_data_in_22_ CLKBUFX2TS
XFE_OFC1680_acc_fir_data_in_22_ FE_OFN1680_acc_fir_data_in_22_
+ FE_OFN1678_acc_fir_data_in_22_ CLKBUFX2TS
XFE_OFC1679_acc_fir_data_in_22_ FE_OFN1679_acc_fir_data_in_22_
+ FE_OFN1678_acc_fir_data_in_22_ CLKBUFX2TS
XFE_OFC1678_acc_fir_data_in_22_ FE_OFN1678_acc_fir_data_in_22_
+ acc_fir_data_in[22] CLKBUFX2TS
XFE_OFC1677_acc_fir_data_in_23_ FE_OFN1677_acc_fir_data_in_23_
+ FE_OFN1675_acc_fir_data_in_23_ CLKBUFX2TS
XFE_OFC1676_acc_fir_data_in_23_ FE_OFN1676_acc_fir_data_in_23_
+ FE_OFN1674_acc_fir_data_in_23_ CLKINVX1TS
XFE_OFC1675_acc_fir_data_in_23_ FE_OFN1675_acc_fir_data_in_23_
+ FE_OFN1674_acc_fir_data_in_23_ CLKINVX1TS
XFE_OFC1674_acc_fir_data_in_23_ FE_OFN1674_acc_fir_data_in_23_
+ FE_OFN1672_acc_fir_data_in_23_ CLKINVX1TS
XFE_OFC1673_acc_fir_data_in_23_ FE_OFN1673_acc_fir_data_in_23_
+ FE_OFN1672_acc_fir_data_in_23_ CLKBUFX2TS
XFE_OFC1672_acc_fir_data_in_23_ FE_OFN1672_acc_fir_data_in_23_
+ FE_OFN1671_acc_fir_data_in_23_ CLKBUFX2TS
XFE_OFC1671_acc_fir_data_in_23_ FE_OFN1671_acc_fir_data_in_23_
+ acc_fir_data_in[23] CLKBUFX2TS
XFE_OFC1670_acc_fir_data_in_24_ FE_OFN1670_acc_fir_data_in_24_
+ FE_OFN1669_acc_fir_data_in_24_ CLKBUFX2TS
XFE_OFC1669_acc_fir_data_in_24_ FE_OFN1669_acc_fir_data_in_24_
+ FE_OFN1667_acc_fir_data_in_24_ CLKBUFX2TS
XFE_OFC1668_acc_fir_data_in_24_ FE_OFN1668_acc_fir_data_in_24_
+ FE_OFN1667_acc_fir_data_in_24_ CLKBUFX2TS
XFE_OFC1667_acc_fir_data_in_24_ FE_OFN1667_acc_fir_data_in_24_
+ FE_OFN1666_acc_fir_data_in_24_ CLKBUFX2TS
XFE_OFC1666_acc_fir_data_in_24_ FE_OFN1666_acc_fir_data_in_24_
+ acc_fir_data_in[24] CLKBUFX2TS
XFE_OFC1665_acc_fir_data_in_25_ FE_OFN1665_acc_fir_data_in_25_
+ FE_OFN1664_acc_fir_data_in_25_ CLKBUFX2TS
XFE_OFC1664_acc_fir_data_in_25_ FE_OFN1664_acc_fir_data_in_25_
+ FE_OFN1663_acc_fir_data_in_25_ CLKBUFX2TS
XFE_OFC1663_acc_fir_data_in_25_ FE_OFN1663_acc_fir_data_in_25_
+ FE_OFN1662_acc_fir_data_in_25_ CLKBUFX2TS
XFE_OFC1662_acc_fir_data_in_25_ FE_OFN1662_acc_fir_data_in_25_
+ FE_OFN1661_acc_fir_data_in_25_ CLKBUFX2TS
XFE_OFC1661_acc_fir_data_in_25_ FE_OFN1661_acc_fir_data_in_25_
+ acc_fir_data_in[25] CLKBUFX2TS
XFE_OFC1660_acc_fir_data_in_26_ FE_OFN1660_acc_fir_data_in_26_
+ FE_OFN1659_acc_fir_data_in_26_ CLKBUFX2TS
XFE_OFC1659_acc_fir_data_in_26_ FE_OFN1659_acc_fir_data_in_26_
+ FE_OFN1818_acc_fir_data_in_26_ CLKBUFX2TS
XFE_OFC1658_acc_fir_data_in_26_ FE_OFN1658_acc_fir_data_in_26_
+ FE_OFN1657_acc_fir_data_in_26_ CLKBUFX2TS
XFE_OFC1657_acc_fir_data_in_26_ FE_OFN1657_acc_fir_data_in_26_
+ FE_OFN1818_acc_fir_data_in_26_ CLKBUFX2TS
XFE_OFC1656_acc_fir_data_in_26_ FE_OFN1656_acc_fir_data_in_26_
+ acc_fir_data_in[26] CLKBUFX2TS
XFE_OFC1655_acc_fir_data_in_27_ FE_OFN1655_acc_fir_data_in_27_
+ FE_OFN1653_acc_fir_data_in_27_ CLKBUFX2TS
XFE_OFC1654_acc_fir_data_in_27_ FE_OFN1654_acc_fir_data_in_27_
+ FE_OFN1652_acc_fir_data_in_27_ CLKBUFX2TS
XFE_OFC1653_acc_fir_data_in_27_ FE_OFN1653_acc_fir_data_in_27_
+ FE_OFN1651_acc_fir_data_in_27_ CLKBUFX2TS
XFE_OFC1652_acc_fir_data_in_27_ FE_OFN1652_acc_fir_data_in_27_
+ FE_OFN1651_acc_fir_data_in_27_ CLKBUFX2TS
XFE_OFC1651_acc_fir_data_in_27_ FE_OFN1651_acc_fir_data_in_27_
+ acc_fir_data_in[27] CLKBUFX2TS
XFE_OFC1650_acc_fir_data_in_28_ FE_OFN1650_acc_fir_data_in_28_
+ FE_OFN1648_acc_fir_data_in_28_ CLKBUFX2TS
XFE_OFC1649_acc_fir_data_in_28_ FE_OFN1649_acc_fir_data_in_28_
+ FE_OFN1647_acc_fir_data_in_28_ CLKBUFX2TS
XFE_OFC1648_acc_fir_data_in_28_ FE_OFN1648_acc_fir_data_in_28_
+ FE_OFN1646_acc_fir_data_in_28_ CLKBUFX2TS
XFE_OFC1647_acc_fir_data_in_28_ FE_OFN1647_acc_fir_data_in_28_
+ FE_OFN1646_acc_fir_data_in_28_ CLKBUFX2TS
XFE_OFC1646_acc_fir_data_in_28_ FE_OFN1646_acc_fir_data_in_28_
+ acc_fir_data_in[28] CLKBUFX2TS
XFE_OFC1645_acc_fir_data_in_29_ FE_OFN1645_acc_fir_data_in_29_
+ FE_OFN1643_acc_fir_data_in_29_ CLKBUFX2TS
XFE_OFC1644_acc_fir_data_in_29_ FE_OFN1644_acc_fir_data_in_29_
+ FE_OFN1643_acc_fir_data_in_29_ CLKBUFX2TS
XFE_OFC1643_acc_fir_data_in_29_ FE_OFN1643_acc_fir_data_in_29_
+ FE_OFN1641_acc_fir_data_in_29_ CLKBUFX2TS
XFE_OFC1642_acc_fir_data_in_29_ FE_OFN1642_acc_fir_data_in_29_
+ FE_OFN1639_acc_fir_data_in_29_ CLKINVX1TS
XFE_OFC1641_acc_fir_data_in_29_ FE_OFN1641_acc_fir_data_in_29_
+ FE_OFN1639_acc_fir_data_in_29_ CLKINVX1TS
XFE_OFC1640_acc_fir_data_in_29_ FE_OFN1640_acc_fir_data_in_29_
+ FE_OFN1639_acc_fir_data_in_29_ CLKINVX1TS
XFE_OFC1639_acc_fir_data_in_29_ FE_OFN1639_acc_fir_data_in_29_
+ FE_OFN1638_acc_fir_data_in_29_ CLKINVX1TS
XFE_OFC1638_acc_fir_data_in_29_ FE_OFN1638_acc_fir_data_in_29_
+ acc_fir_data_in[29] CLKBUFX2TS
XFE_OFC1637_acc_fir_data_in_30_ FE_OFN1637_acc_fir_data_in_30_
+ FE_OFN1635_acc_fir_data_in_30_ CLKBUFX2TS
XFE_OFC1636_acc_fir_data_in_30_ FE_OFN1636_acc_fir_data_in_30_
+ FE_OFN1634_acc_fir_data_in_30_ CLKBUFX2TS
XFE_OFC1635_acc_fir_data_in_30_ FE_OFN1635_acc_fir_data_in_30_
+ FE_OFN1633_acc_fir_data_in_30_ CLKBUFX2TS
XFE_OFC1634_acc_fir_data_in_30_ FE_OFN1634_acc_fir_data_in_30_
+ FE_OFN1633_acc_fir_data_in_30_ CLKBUFX2TS
XFE_OFC1633_acc_fir_data_in_30_ FE_OFN1633_acc_fir_data_in_30_
+ acc_fir_data_in[30] CLKBUFX2TS
XFE_OFC1632_acc_fir_data_in_31_ FE_OFN1632_acc_fir_data_in_31_
+ FE_OFN1630_acc_fir_data_in_31_ CLKBUFX2TS
XFE_OFC1631_acc_fir_data_in_31_ FE_OFN1631_acc_fir_data_in_31_
+ FE_OFN1630_acc_fir_data_in_31_ CLKBUFX2TS
XFE_OFC1630_acc_fir_data_in_31_ FE_OFN1630_acc_fir_data_in_31_
+ FE_OFN1629_acc_fir_data_in_31_ CLKBUFX2TS
XFE_OFC1629_acc_fir_data_in_31_ FE_OFN1629_acc_fir_data_in_31_
+ FE_OFN1628_acc_fir_data_in_31_ CLKBUFX2TS
XFE_OFC1628_acc_fir_data_in_31_ FE_OFN1628_acc_fir_data_in_31_
+ acc_fir_data_in[31] CLKBUFX2TS
XFE_OFC1627_acc_fft_data_in_0_ FE_OFN1627_acc_fft_data_in_0_
+ FE_OFN1626_acc_fft_data_in_0_ CLKBUFX2TS
XFE_OFC1626_acc_fft_data_in_0_ FE_OFN1626_acc_fft_data_in_0_
+ FE_OFN1625_acc_fft_data_in_0_ CLKBUFX2TS
XFE_OFC1625_acc_fft_data_in_0_ FE_OFN1625_acc_fft_data_in_0_
+ FE_OFN1624_acc_fft_data_in_0_ CLKBUFX2TS
XFE_OFC1624_acc_fft_data_in_0_ FE_OFN1624_acc_fft_data_in_0_
+ FE_OFN1623_acc_fft_data_in_0_ CLKBUFX2TS
XFE_OFC1623_acc_fft_data_in_0_ FE_OFN1623_acc_fft_data_in_0_
+ FE_OFN1622_acc_fft_data_in_0_ CLKBUFX2TS
XFE_OFC1622_acc_fft_data_in_0_ FE_OFN1622_acc_fft_data_in_0_ acc_fft_data_in[0]
+ CLKBUFX2TS
XFE_OFC1621_acc_fft_data_in_1_ FE_OFN1621_acc_fft_data_in_1_
+ FE_OFN1619_acc_fft_data_in_1_ CLKINVX1TS
XFE_OFC1620_acc_fft_data_in_1_ FE_OFN1620_acc_fft_data_in_1_
+ FE_OFN1619_acc_fft_data_in_1_ CLKINVX1TS
XFE_OFC1619_acc_fft_data_in_1_ FE_OFN1619_acc_fft_data_in_1_
+ FE_OFN1618_acc_fft_data_in_1_ CLKINVX1TS
XFE_OFC1618_acc_fft_data_in_1_ FE_OFN1618_acc_fft_data_in_1_
+ FE_OFN1617_acc_fft_data_in_1_ CLKBUFX2TS
XFE_OFC1617_acc_fft_data_in_1_ FE_OFN1617_acc_fft_data_in_1_
+ FE_OFN1616_acc_fft_data_in_1_ CLKBUFX2TS
XFE_OFC1616_acc_fft_data_in_1_ FE_OFN1616_acc_fft_data_in_1_
+ FE_OFN1615_acc_fft_data_in_1_ CLKBUFX2TS
XFE_OFC1615_acc_fft_data_in_1_ FE_OFN1615_acc_fft_data_in_1_ acc_fft_data_in[1]
+ CLKBUFX2TS
XFE_OFC1614_acc_fft_data_in_2_ FE_OFN1614_acc_fft_data_in_2_
+ FE_OFN1612_acc_fft_data_in_2_ CLKBUFX2TS
XFE_OFC1613_acc_fft_data_in_2_ FE_OFN1613_acc_fft_data_in_2_
+ FE_OFN1611_acc_fft_data_in_2_ CLKINVX1TS
XFE_OFC1612_acc_fft_data_in_2_ FE_OFN1612_acc_fft_data_in_2_
+ FE_OFN1611_acc_fft_data_in_2_ CLKINVX1TS
XFE_OFC1611_acc_fft_data_in_2_ FE_OFN1611_acc_fft_data_in_2_
+ FE_OFN1610_acc_fft_data_in_2_ CLKINVX1TS
XFE_OFC1610_acc_fft_data_in_2_ FE_OFN1610_acc_fft_data_in_2_
+ FE_OFN1609_acc_fft_data_in_2_ CLKBUFX2TS
XFE_OFC1609_acc_fft_data_in_2_ FE_OFN1609_acc_fft_data_in_2_
+ FE_OFN1608_acc_fft_data_in_2_ CLKBUFX2TS
XFE_OFC1608_acc_fft_data_in_2_ FE_OFN1608_acc_fft_data_in_2_ acc_fft_data_in[2]
+ CLKBUFX2TS
XFE_OFC1607_acc_fft_data_in_3_ FE_OFN1607_acc_fft_data_in_3_
+ FE_OFN1605_acc_fft_data_in_3_ CLKBUFX2TS
XFE_OFC1606_acc_fft_data_in_3_ FE_OFN1606_acc_fft_data_in_3_
+ FE_OFN1605_acc_fft_data_in_3_ CLKBUFX2TS
XFE_OFC1605_acc_fft_data_in_3_ FE_OFN1605_acc_fft_data_in_3_
+ FE_OFN1604_acc_fft_data_in_3_ CLKBUFX2TS
XFE_OFC1604_acc_fft_data_in_3_ FE_OFN1604_acc_fft_data_in_3_
+ FE_OFN1603_acc_fft_data_in_3_ CLKBUFX2TS
XFE_OFC1603_acc_fft_data_in_3_ FE_OFN1603_acc_fft_data_in_3_ acc_fft_data_in[3]
+ CLKBUFX2TS
XFE_OFC1602_acc_fft_data_in_4_ FE_OFN1602_acc_fft_data_in_4_
+ FE_OFN1601_acc_fft_data_in_4_ CLKBUFX2TS
XFE_OFC1601_acc_fft_data_in_4_ FE_OFN1601_acc_fft_data_in_4_
+ FE_OFN1600_acc_fft_data_in_4_ CLKBUFX2TS
XFE_OFC1600_acc_fft_data_in_4_ FE_OFN1600_acc_fft_data_in_4_
+ FE_OFN1597_acc_fft_data_in_4_ CLKBUFX2TS
XFE_OFC1599_acc_fft_data_in_4_ FE_OFN1599_acc_fft_data_in_4_
+ FE_OFN1598_acc_fft_data_in_4_ CLKBUFX2TS
XFE_OFC1598_acc_fft_data_in_4_ FE_OFN1598_acc_fft_data_in_4_
+ FE_OFN1596_acc_fft_data_in_4_ CLKINVX1TS
XFE_OFC1597_acc_fft_data_in_4_ FE_OFN1597_acc_fft_data_in_4_
+ FE_OFN1596_acc_fft_data_in_4_ CLKINVX1TS
XFE_OFC1596_acc_fft_data_in_4_ FE_OFN1596_acc_fft_data_in_4_ acc_fft_data_in[4]
+ CLKINVX2TS
XFE_OFC1595_acc_fft_data_in_5_ FE_OFN1595_acc_fft_data_in_5_
+ FE_OFN1593_acc_fft_data_in_5_ CLKBUFX2TS
XFE_OFC1594_acc_fft_data_in_5_ FE_OFN1594_acc_fft_data_in_5_
+ FE_OFN1592_acc_fft_data_in_5_ CLKBUFX2TS
XFE_OFC1593_acc_fft_data_in_5_ FE_OFN1593_acc_fft_data_in_5_
+ FE_OFN1592_acc_fft_data_in_5_ CLKBUFX2TS
XFE_OFC1592_acc_fft_data_in_5_ FE_OFN1592_acc_fft_data_in_5_
+ FE_OFN1591_acc_fft_data_in_5_ CLKBUFX2TS
XFE_OFC1591_acc_fft_data_in_5_ FE_OFN1591_acc_fft_data_in_5_ acc_fft_data_in[5]
+ CLKBUFX2TS
XFE_OFC1590_acc_fft_data_in_6_ FE_OFN1590_acc_fft_data_in_6_
+ FE_OFN1588_acc_fft_data_in_6_ CLKBUFX2TS
XFE_OFC1589_acc_fft_data_in_6_ FE_OFN1589_acc_fft_data_in_6_
+ FE_OFN1588_acc_fft_data_in_6_ CLKBUFX2TS
XFE_OFC1588_acc_fft_data_in_6_ FE_OFN1588_acc_fft_data_in_6_
+ FE_OFN1587_acc_fft_data_in_6_ CLKBUFX2TS
XFE_OFC1587_acc_fft_data_in_6_ FE_OFN1587_acc_fft_data_in_6_
+ FE_OFN1586_acc_fft_data_in_6_ CLKBUFX2TS
XFE_OFC1586_acc_fft_data_in_6_ FE_OFN1586_acc_fft_data_in_6_
+ FE_OFN1585_acc_fft_data_in_6_ CLKBUFX2TS
XFE_OFC1585_acc_fft_data_in_6_ FE_OFN1585_acc_fft_data_in_6_ acc_fft_data_in[6]
+ CLKBUFX2TS
XFE_OFC1584_acc_fft_data_in_7_ FE_OFN1584_acc_fft_data_in_7_
+ FE_OFN1583_acc_fft_data_in_7_ CLKBUFX2TS
XFE_OFC1583_acc_fft_data_in_7_ FE_OFN1583_acc_fft_data_in_7_
+ FE_OFN1582_acc_fft_data_in_7_ CLKBUFX2TS
XFE_OFC1582_acc_fft_data_in_7_ FE_OFN1582_acc_fft_data_in_7_
+ FE_OFN1580_acc_fft_data_in_7_ CLKBUFX2TS
XFE_OFC1581_acc_fft_data_in_7_ FE_OFN1581_acc_fft_data_in_7_
+ FE_OFN1580_acc_fft_data_in_7_ CLKBUFX2TS
XFE_OFC1580_acc_fft_data_in_7_ FE_OFN1580_acc_fft_data_in_7_ acc_fft_data_in[7]
+ CLKBUFX2TS
XFE_OFC1579_acc_fft_data_in_8_ FE_OFN1579_acc_fft_data_in_8_
+ FE_OFN1578_acc_fft_data_in_8_ CLKBUFX2TS
XFE_OFC1578_acc_fft_data_in_8_ FE_OFN1578_acc_fft_data_in_8_
+ FE_OFN1577_acc_fft_data_in_8_ CLKBUFX2TS
XFE_OFC1577_acc_fft_data_in_8_ FE_OFN1577_acc_fft_data_in_8_
+ FE_OFN1576_acc_fft_data_in_8_ CLKBUFX2TS
XFE_OFC1576_acc_fft_data_in_8_ FE_OFN1576_acc_fft_data_in_8_
+ FE_OFN1575_acc_fft_data_in_8_ CLKBUFX2TS
XFE_OFC1575_acc_fft_data_in_8_ FE_OFN1575_acc_fft_data_in_8_
+ FE_OFN1574_acc_fft_data_in_8_ CLKBUFX2TS
XFE_OFC1574_acc_fft_data_in_8_ FE_OFN1574_acc_fft_data_in_8_ acc_fft_data_in[8]
+ CLKBUFX2TS
XFE_OFC1573_acc_fft_data_in_9_ FE_OFN1573_acc_fft_data_in_9_
+ FE_OFN1571_acc_fft_data_in_9_ CLKBUFX2TS
XFE_OFC1572_acc_fft_data_in_9_ FE_OFN1572_acc_fft_data_in_9_
+ FE_OFN1570_acc_fft_data_in_9_ CLKBUFX2TS
XFE_OFC1571_acc_fft_data_in_9_ FE_OFN1571_acc_fft_data_in_9_
+ FE_OFN1569_acc_fft_data_in_9_ CLKBUFX2TS
XFE_OFC1570_acc_fft_data_in_9_ FE_OFN1570_acc_fft_data_in_9_
+ FE_OFN1569_acc_fft_data_in_9_ CLKBUFX2TS
XFE_OFC1569_acc_fft_data_in_9_ FE_OFN1569_acc_fft_data_in_9_ acc_fft_data_in[9]
+ CLKBUFX2TS
XFE_OFC1568_acc_fft_data_in_10_ FE_OFN1568_acc_fft_data_in_10_
+ FE_OFN1565_acc_fft_data_in_10_ CLKBUFX2TS
XFE_OFC1567_acc_fft_data_in_10_ FE_OFN1567_acc_fft_data_in_10_
+ FE_OFN1566_acc_fft_data_in_10_ CLKBUFX2TS
XFE_OFC1566_acc_fft_data_in_10_ FE_OFN1566_acc_fft_data_in_10_
+ FE_OFN1564_acc_fft_data_in_10_ CLKBUFX2TS
XFE_OFC1565_acc_fft_data_in_10_ FE_OFN1565_acc_fft_data_in_10_
+ FE_OFN1564_acc_fft_data_in_10_ CLKBUFX2TS
XFE_OFC1564_acc_fft_data_in_10_ FE_OFN1564_acc_fft_data_in_10_
+ acc_fft_data_in[10] CLKBUFX2TS
XFE_OFC1563_acc_fft_data_in_11_ FE_OFN1563_acc_fft_data_in_11_
+ FE_OFN1562_acc_fft_data_in_11_ CLKBUFX2TS
XFE_OFC1562_acc_fft_data_in_11_ FE_OFN1562_acc_fft_data_in_11_
+ FE_OFN1560_acc_fft_data_in_11_ CLKBUFX2TS
XFE_OFC1561_acc_fft_data_in_11_ FE_OFN1561_acc_fft_data_in_11_
+ FE_OFN1560_acc_fft_data_in_11_ CLKBUFX2TS
XFE_OFC1560_acc_fft_data_in_11_ FE_OFN1560_acc_fft_data_in_11_
+ FE_OFN1559_acc_fft_data_in_11_ CLKBUFX2TS
XFE_OFC1559_acc_fft_data_in_11_ FE_OFN1559_acc_fft_data_in_11_
+ acc_fft_data_in[11] CLKBUFX2TS
XFE_OFC1558_acc_fft_data_in_12_ FE_OFN1558_acc_fft_data_in_12_
+ FE_OFN1557_acc_fft_data_in_12_ CLKBUFX2TS
XFE_OFC1557_acc_fft_data_in_12_ FE_OFN1557_acc_fft_data_in_12_
+ FE_OFN1556_acc_fft_data_in_12_ CLKBUFX2TS
XFE_OFC1556_acc_fft_data_in_12_ FE_OFN1556_acc_fft_data_in_12_
+ FE_OFN1554_acc_fft_data_in_12_ CLKBUFX2TS
XFE_OFC1555_acc_fft_data_in_12_ FE_OFN1555_acc_fft_data_in_12_
+ FE_OFN1554_acc_fft_data_in_12_ CLKBUFX2TS
XFE_OFC1554_acc_fft_data_in_12_ FE_OFN1554_acc_fft_data_in_12_
+ FE_OFN1553_acc_fft_data_in_12_ CLKBUFX2TS
XFE_OFC1553_acc_fft_data_in_12_ FE_OFN1553_acc_fft_data_in_12_
+ acc_fft_data_in[12] CLKBUFX2TS
XFE_OFC1552_acc_fft_data_in_13_ FE_OFN1552_acc_fft_data_in_13_
+ FE_OFN1551_acc_fft_data_in_13_ CLKBUFX2TS
XFE_OFC1551_acc_fft_data_in_13_ FE_OFN1551_acc_fft_data_in_13_
+ FE_OFN1550_acc_fft_data_in_13_ CLKBUFX2TS
XFE_OFC1550_acc_fft_data_in_13_ FE_OFN1550_acc_fft_data_in_13_
+ FE_OFN1549_acc_fft_data_in_13_ CLKBUFX2TS
XFE_OFC1549_acc_fft_data_in_13_ FE_OFN1549_acc_fft_data_in_13_
+ FE_OFN1548_acc_fft_data_in_13_ CLKBUFX2TS
XFE_OFC1548_acc_fft_data_in_13_ FE_OFN1548_acc_fft_data_in_13_
+ acc_fft_data_in[13] CLKBUFX2TS
XFE_OFC1547_acc_fft_data_in_14_ FE_OFN1547_acc_fft_data_in_14_
+ FE_OFN1545_acc_fft_data_in_14_ CLKBUFX2TS
XFE_OFC1546_acc_fft_data_in_14_ FE_OFN1546_acc_fft_data_in_14_
+ FE_OFN1545_acc_fft_data_in_14_ CLKBUFX2TS
XFE_OFC1545_acc_fft_data_in_14_ FE_OFN1545_acc_fft_data_in_14_
+ FE_OFN1544_acc_fft_data_in_14_ CLKBUFX2TS
XFE_OFC1544_acc_fft_data_in_14_ FE_OFN1544_acc_fft_data_in_14_
+ FE_OFN1543_acc_fft_data_in_14_ CLKBUFX2TS
XFE_OFC1543_acc_fft_data_in_14_ FE_OFN1543_acc_fft_data_in_14_
+ acc_fft_data_in[14] CLKBUFX2TS
XFE_OFC1542_acc_fft_data_in_15_ FE_OFN1542_acc_fft_data_in_15_
+ FE_OFN1541_acc_fft_data_in_15_ CLKBUFX2TS
XFE_OFC1541_acc_fft_data_in_15_ FE_OFN1541_acc_fft_data_in_15_
+ FE_OFN1540_acc_fft_data_in_15_ CLKBUFX2TS
XFE_OFC1540_acc_fft_data_in_15_ FE_OFN1540_acc_fft_data_in_15_
+ FE_OFN1539_acc_fft_data_in_15_ CLKBUFX2TS
XFE_OFC1539_acc_fft_data_in_15_ FE_OFN1539_acc_fft_data_in_15_
+ FE_OFN1538_acc_fft_data_in_15_ CLKBUFX2TS
XFE_OFC1538_acc_fft_data_in_15_ FE_OFN1538_acc_fft_data_in_15_
+ acc_fft_data_in[15] CLKBUFX2TS
XFE_OFC1537_acc_fft_data_in_16_ FE_OFN1537_acc_fft_data_in_16_
+ FE_OFN1536_acc_fft_data_in_16_ CLKBUFX2TS
XFE_OFC1536_acc_fft_data_in_16_ FE_OFN1536_acc_fft_data_in_16_
+ FE_OFN1535_acc_fft_data_in_16_ CLKBUFX2TS
XFE_OFC1535_acc_fft_data_in_16_ FE_OFN1535_acc_fft_data_in_16_
+ FE_OFN1534_acc_fft_data_in_16_ CLKBUFX2TS
XFE_OFC1534_acc_fft_data_in_16_ FE_OFN1534_acc_fft_data_in_16_
+ FE_OFN1533_acc_fft_data_in_16_ CLKBUFX2TS
XFE_OFC1533_acc_fft_data_in_16_ FE_OFN1533_acc_fft_data_in_16_
+ acc_fft_data_in[16] CLKBUFX2TS
XFE_OFC1532_acc_fft_data_in_17_ FE_OFN1532_acc_fft_data_in_17_
+ FE_OFN1531_acc_fft_data_in_17_ CLKBUFX2TS
XFE_OFC1531_acc_fft_data_in_17_ FE_OFN1531_acc_fft_data_in_17_
+ FE_OFN1530_acc_fft_data_in_17_ CLKBUFX2TS
XFE_OFC1530_acc_fft_data_in_17_ FE_OFN1530_acc_fft_data_in_17_
+ FE_OFN1529_acc_fft_data_in_17_ CLKBUFX2TS
XFE_OFC1529_acc_fft_data_in_17_ FE_OFN1529_acc_fft_data_in_17_
+ FE_OFN1528_acc_fft_data_in_17_ CLKBUFX2TS
XFE_OFC1528_acc_fft_data_in_17_ FE_OFN1528_acc_fft_data_in_17_
+ FE_OFN1527_acc_fft_data_in_17_ CLKBUFX2TS
XFE_OFC1527_acc_fft_data_in_17_ FE_OFN1527_acc_fft_data_in_17_
+ acc_fft_data_in[17] CLKBUFX2TS
XFE_OFC1526_acc_fft_data_in_18_ FE_OFN1526_acc_fft_data_in_18_
+ FE_OFN1522_acc_fft_data_in_18_ CLKBUFX2TS
XFE_OFC1525_acc_fft_data_in_18_ FE_OFN1525_acc_fft_data_in_18_
+ FE_OFN1524_acc_fft_data_in_18_ CLKBUFX2TS
XFE_OFC1524_acc_fft_data_in_18_ FE_OFN1524_acc_fft_data_in_18_
+ FE_OFN1521_acc_fft_data_in_18_ CLKINVX1TS
XFE_OFC1523_acc_fft_data_in_18_ FE_OFN1523_acc_fft_data_in_18_
+ FE_OFN1521_acc_fft_data_in_18_ CLKINVX1TS
XFE_OFC1522_acc_fft_data_in_18_ FE_OFN1522_acc_fft_data_in_18_
+ FE_OFN1520_acc_fft_data_in_18_ CLKBUFX2TS
XFE_OFC1521_acc_fft_data_in_18_ FE_OFN1521_acc_fft_data_in_18_
+ FE_OFN1520_acc_fft_data_in_18_ CLKINVX1TS
XFE_OFC1520_acc_fft_data_in_18_ FE_OFN1520_acc_fft_data_in_18_
+ acc_fft_data_in[18] CLKBUFX2TS
XFE_OFC1519_acc_fft_data_in_19_ FE_OFN1519_acc_fft_data_in_19_
+ FE_OFN1518_acc_fft_data_in_19_ CLKBUFX2TS
XFE_OFC1518_acc_fft_data_in_19_ FE_OFN1518_acc_fft_data_in_19_
+ FE_OFN1517_acc_fft_data_in_19_ CLKBUFX2TS
XFE_OFC1517_acc_fft_data_in_19_ FE_OFN1517_acc_fft_data_in_19_
+ FE_OFN1516_acc_fft_data_in_19_ CLKBUFX2TS
XFE_OFC1516_acc_fft_data_in_19_ FE_OFN1516_acc_fft_data_in_19_
+ FE_OFN1515_acc_fft_data_in_19_ CLKBUFX2TS
XFE_OFC1515_acc_fft_data_in_19_ FE_OFN1515_acc_fft_data_in_19_
+ acc_fft_data_in[19] CLKBUFX2TS
XFE_OFC1514_acc_fft_data_in_20_ FE_OFN1514_acc_fft_data_in_20_
+ FE_OFN1513_acc_fft_data_in_20_ CLKBUFX2TS
XFE_OFC1513_acc_fft_data_in_20_ FE_OFN1513_acc_fft_data_in_20_
+ FE_OFN1512_acc_fft_data_in_20_ CLKBUFX2TS
XFE_OFC1512_acc_fft_data_in_20_ FE_OFN1512_acc_fft_data_in_20_
+ FE_OFN1511_acc_fft_data_in_20_ CLKBUFX2TS
XFE_OFC1511_acc_fft_data_in_20_ FE_OFN1511_acc_fft_data_in_20_
+ FE_OFN1510_acc_fft_data_in_20_ CLKBUFX2TS
XFE_OFC1510_acc_fft_data_in_20_ FE_OFN1510_acc_fft_data_in_20_
+ acc_fft_data_in[20] CLKBUFX2TS
XFE_OFC1509_acc_fft_data_in_21_ FE_OFN1509_acc_fft_data_in_21_
+ FE_OFN1507_acc_fft_data_in_21_ CLKBUFX2TS
XFE_OFC1508_acc_fft_data_in_21_ FE_OFN1508_acc_fft_data_in_21_
+ FE_OFN1506_acc_fft_data_in_21_ CLKBUFX2TS
XFE_OFC1507_acc_fft_data_in_21_ FE_OFN1507_acc_fft_data_in_21_
+ FE_OFN1505_acc_fft_data_in_21_ CLKBUFX2TS
XFE_OFC1506_acc_fft_data_in_21_ FE_OFN1506_acc_fft_data_in_21_
+ FE_OFN1505_acc_fft_data_in_21_ CLKBUFX2TS
XFE_OFC1505_acc_fft_data_in_21_ FE_OFN1505_acc_fft_data_in_21_
+ acc_fft_data_in[21] CLKBUFX2TS
XFE_OFC1504_acc_fft_data_in_22_ FE_OFN1504_acc_fft_data_in_22_
+ FE_OFN1502_acc_fft_data_in_22_ CLKINVX1TS
XFE_OFC1503_acc_fft_data_in_22_ FE_OFN1503_acc_fft_data_in_22_
+ FE_OFN1502_acc_fft_data_in_22_ CLKINVX1TS
XFE_OFC1502_acc_fft_data_in_22_ FE_OFN1502_acc_fft_data_in_22_
+ FE_OFN1499_acc_fft_data_in_22_ CLKINVX1TS
XFE_OFC1501_acc_fft_data_in_22_ FE_OFN1501_acc_fft_data_in_22_
+ FE_OFN1500_acc_fft_data_in_22_ CLKBUFX2TS
XFE_OFC1500_acc_fft_data_in_22_ FE_OFN1500_acc_fft_data_in_22_
+ FE_OFN1499_acc_fft_data_in_22_ CLKBUFX2TS
XFE_OFC1499_acc_fft_data_in_22_ FE_OFN1499_acc_fft_data_in_22_
+ FE_OFN1498_acc_fft_data_in_22_ CLKBUFX2TS
XFE_OFC1498_acc_fft_data_in_22_ FE_OFN1498_acc_fft_data_in_22_
+ acc_fft_data_in[22] CLKBUFX2TS
XFE_OFC1497_acc_fft_data_in_23_ FE_OFN1497_acc_fft_data_in_23_
+ FE_OFN1496_acc_fft_data_in_23_ CLKBUFX2TS
XFE_OFC1496_acc_fft_data_in_23_ FE_OFN1496_acc_fft_data_in_23_
+ FE_OFN1493_acc_fft_data_in_23_ CLKBUFX2TS
XFE_OFC1495_acc_fft_data_in_23_ FE_OFN1495_acc_fft_data_in_23_
+ FE_OFN1493_acc_fft_data_in_23_ CLKBUFX2TS
XFE_OFC1494_acc_fft_data_in_23_ FE_OFN1494_acc_fft_data_in_23_
+ FE_OFN1493_acc_fft_data_in_23_ CLKBUFX2TS
XFE_OFC1493_acc_fft_data_in_23_ FE_OFN1493_acc_fft_data_in_23_
+ acc_fft_data_in[23] CLKBUFX2TS
XFE_OFC1492_acc_fft_data_in_24_ FE_OFN1492_acc_fft_data_in_24_
+ FE_OFN1489_acc_fft_data_in_24_ CLKBUFX2TS
XFE_OFC1491_acc_fft_data_in_24_ FE_OFN1491_acc_fft_data_in_24_
+ FE_OFN1490_acc_fft_data_in_24_ CLKBUFX2TS
XFE_OFC1490_acc_fft_data_in_24_ FE_OFN1490_acc_fft_data_in_24_
+ FE_OFN1488_acc_fft_data_in_24_ CLKBUFX2TS
XFE_OFC1489_acc_fft_data_in_24_ FE_OFN1489_acc_fft_data_in_24_
+ FE_OFN1488_acc_fft_data_in_24_ CLKBUFX2TS
XFE_OFC1488_acc_fft_data_in_24_ FE_OFN1488_acc_fft_data_in_24_
+ acc_fft_data_in[24] CLKBUFX2TS
XFE_OFC1487_acc_fft_data_in_25_ FE_OFN1487_acc_fft_data_in_25_
+ FE_OFN1485_acc_fft_data_in_25_ CLKBUFX2TS
XFE_OFC1486_acc_fft_data_in_25_ FE_OFN1486_acc_fft_data_in_25_
+ FE_OFN1484_acc_fft_data_in_25_ CLKBUFX2TS
XFE_OFC1485_acc_fft_data_in_25_ FE_OFN1485_acc_fft_data_in_25_
+ FE_OFN1484_acc_fft_data_in_25_ CLKBUFX2TS
XFE_OFC1484_acc_fft_data_in_25_ FE_OFN1484_acc_fft_data_in_25_
+ FE_OFN1483_acc_fft_data_in_25_ CLKBUFX2TS
XFE_OFC1483_acc_fft_data_in_25_ FE_OFN1483_acc_fft_data_in_25_
+ acc_fft_data_in[25] CLKBUFX2TS
XFE_OFC1482_acc_fft_data_in_26_ FE_OFN1482_acc_fft_data_in_26_
+ FE_OFN1481_acc_fft_data_in_26_ CLKBUFX2TS
XFE_OFC1481_acc_fft_data_in_26_ FE_OFN1481_acc_fft_data_in_26_
+ FE_OFN1480_acc_fft_data_in_26_ CLKBUFX2TS
XFE_OFC1480_acc_fft_data_in_26_ FE_OFN1480_acc_fft_data_in_26_
+ FE_OFN1479_acc_fft_data_in_26_ CLKBUFX2TS
XFE_OFC1479_acc_fft_data_in_26_ FE_OFN1479_acc_fft_data_in_26_
+ FE_OFN1478_acc_fft_data_in_26_ CLKBUFX2TS
XFE_OFC1478_acc_fft_data_in_26_ FE_OFN1478_acc_fft_data_in_26_
+ acc_fft_data_in[26] CLKBUFX2TS
XFE_OFC1477_acc_fft_data_in_27_ FE_OFN1477_acc_fft_data_in_27_
+ FE_OFN1476_acc_fft_data_in_27_ CLKBUFX2TS
XFE_OFC1476_acc_fft_data_in_27_ FE_OFN1476_acc_fft_data_in_27_
+ FE_OFN1475_acc_fft_data_in_27_ CLKBUFX2TS
XFE_OFC1475_acc_fft_data_in_27_ FE_OFN1475_acc_fft_data_in_27_
+ FE_OFN1474_acc_fft_data_in_27_ CLKBUFX2TS
XFE_OFC1474_acc_fft_data_in_27_ FE_OFN1474_acc_fft_data_in_27_
+ FE_OFN1473_acc_fft_data_in_27_ CLKBUFX2TS
XFE_OFC1473_acc_fft_data_in_27_ FE_OFN1473_acc_fft_data_in_27_
+ acc_fft_data_in[27] CLKBUFX2TS
XFE_OFC1472_acc_fft_data_in_28_ FE_OFN1472_acc_fft_data_in_28_
+ FE_OFN1470_acc_fft_data_in_28_ CLKBUFX2TS
XFE_OFC1471_acc_fft_data_in_28_ FE_OFN1471_acc_fft_data_in_28_
+ FE_OFN1820_acc_fft_data_in_28_ CLKBUFX2TS
XFE_OFC1470_acc_fft_data_in_28_ FE_OFN1470_acc_fft_data_in_28_
+ FE_OFN1821_acc_fft_data_in_28_ CLKBUFX2TS
XFE_OFC1469_acc_fft_data_in_28_ FE_OFN1469_acc_fft_data_in_28_
+ FE_OFN1468_acc_fft_data_in_28_ CLKBUFX2TS
XFE_OFC1468_acc_fft_data_in_28_ FE_OFN1468_acc_fft_data_in_28_
+ acc_fft_data_in[28] CLKBUFX2TS
XFE_OFC1467_acc_fft_data_in_29_ FE_OFN1467_acc_fft_data_in_29_
+ FE_OFN1465_acc_fft_data_in_29_ CLKBUFX2TS
XFE_OFC1466_acc_fft_data_in_29_ FE_OFN1466_acc_fft_data_in_29_
+ FE_OFN1464_acc_fft_data_in_29_ CLKBUFX2TS
XFE_OFC1465_acc_fft_data_in_29_ FE_OFN1465_acc_fft_data_in_29_
+ FE_OFN1463_acc_fft_data_in_29_ CLKBUFX2TS
XFE_OFC1464_acc_fft_data_in_29_ FE_OFN1464_acc_fft_data_in_29_
+ FE_OFN1463_acc_fft_data_in_29_ CLKBUFX2TS
XFE_OFC1463_acc_fft_data_in_29_ FE_OFN1463_acc_fft_data_in_29_
+ acc_fft_data_in[29] CLKBUFX2TS
XFE_OFC1462_acc_fft_data_in_30_ FE_OFN1462_acc_fft_data_in_30_
+ FE_OFN1459_acc_fft_data_in_30_ CLKBUFX2TS
XFE_OFC1461_acc_fft_data_in_30_ FE_OFN1461_acc_fft_data_in_30_
+ FE_OFN1460_acc_fft_data_in_30_ CLKBUFX2TS
XFE_OFC1460_acc_fft_data_in_30_ FE_OFN1460_acc_fft_data_in_30_
+ FE_OFN1458_acc_fft_data_in_30_ CLKBUFX2TS
XFE_OFC1459_acc_fft_data_in_30_ FE_OFN1459_acc_fft_data_in_30_
+ FE_OFN1458_acc_fft_data_in_30_ CLKBUFX2TS
XFE_OFC1458_acc_fft_data_in_30_ FE_OFN1458_acc_fft_data_in_30_
+ acc_fft_data_in[30] CLKBUFX2TS
XFE_OFC1457_acc_fft_data_in_31_ FE_OFN1457_acc_fft_data_in_31_
+ FE_OFN1455_acc_fft_data_in_31_ CLKBUFX2TS
XFE_OFC1456_acc_fft_data_in_31_ FE_OFN1456_acc_fft_data_in_31_
+ FE_OFN1454_acc_fft_data_in_31_ CLKBUFX2TS
XFE_OFC1455_acc_fft_data_in_31_ FE_OFN1455_acc_fft_data_in_31_
+ FE_OFN1452_acc_fft_data_in_31_ CLKBUFX2TS
XFE_OFC1454_acc_fft_data_in_31_ FE_OFN1454_acc_fft_data_in_31_
+ FE_OFN1452_acc_fft_data_in_31_ CLKBUFX2TS
XFE_OFC1453_acc_fft_data_in_31_ FE_OFN1453_acc_fft_data_in_31_
+ FE_OFN1452_acc_fft_data_in_31_ CLKBUFX2TS
XFE_OFC1452_acc_fft_data_in_31_ FE_OFN1452_acc_fft_data_in_31_
+ acc_fft_data_in[31] CLKBUFX2TS
XFE_OFC1451_acc_fir_put FE_OFN1451_acc_fir_put acc_fir_put CLKBUFX2TS
XFE_OFC1450_acc_fir_get FE_OFN1450_acc_fir_get acc_fir_get CLKBUFX2TS
XFE_OFC1449_acc_fft_put FE_OFN1449_acc_fft_put acc_fft_put CLKBUFX2TS
XFE_OFC1448_acc_fft_get FE_OFN1448_acc_fft_get acc_fft_get CLKBUFX2TS
XFE_OFC1447_reset FE_OFN1447_reset reset CLKBUFX2TS
XFE_OFC1446_router_addr_calc_fir_read_calc_count_0_
+ FE_OFN1446_router_addr_calc_fir_read_calc_count_0_
+ router_addr_calc_fir_read_calc_count[0] CLKBUFX2TS
XFE_OFC1445_router_addr_calc_fir_write_calc_count_0_
+ FE_OFN1445_router_addr_calc_fir_write_calc_count_0_
+ router_addr_calc_fir_write_calc_count[0] CLKBUFX2TS
XFE_OFC1444_router_addr_calc_fft_read_calc_count_0_
+ FE_OFN1444_router_addr_calc_fft_read_calc_count_0_
+ router_addr_calc_fft_read_calc_count[0] CLKBUFX2TS
XFE_OFC1443_router_addr_calc_fft_write_calc_count_0_
+ FE_OFN1443_router_addr_calc_fft_write_calc_count_0_
+ router_addr_calc_fft_write_calc_count[0] CLKBUFX2TS
XFE_OFC1442_router_addr_calc_iir_write_calc_count_0_
+ FE_OFN1442_router_addr_calc_iir_write_calc_count_0_
+ router_addr_calc_iir_write_calc_count[0] CLKBUFX2TS
XFE_OFC1441_router_addr_calc_iir_write_calc_count_16_
+ FE_OFN1441_router_addr_calc_iir_write_calc_count_16_
+ router_addr_calc_iir_write_calc_count[16] CLKBUFX2TS
XFE_OFC1440_router_addr_calc_iir_write_calc_count_19_
+ FE_OFN1440_router_addr_calc_iir_write_calc_count_19_
+ router_addr_calc_iir_write_calc_count[19] CLKBUFX2TS
XFE_OFC1439_router_addr_calc_iir_write_calc_count_27_
+ FE_OFN1439_router_addr_calc_iir_write_calc_count_27_
+ router_addr_calc_iir_write_calc_count[27] CLKBUFX2TS
XFE_OFC1438_router_data_from_fft FE_OFN1438_router_data_from_fft
+ router_data_from_fft CLKBUFX2TS
XFE_OFC1437_n8093 FE_OFN1437_n8093 FE_OFN1436_n8093 CLKBUFX2TS
XFE_OFC1436_n8093 FE_OFN1436_n8093 FE_OFN1434_n8093 CLKBUFX2TS
XFE_OFC1435_n8093 FE_OFN1435_n8093 FE_OFN1434_n8093 CLKBUFX2TS
XFE_OFC1434_n8093 FE_OFN1434_n8093 FE_OFN1433_n8093 CLKBUFX2TS
XFE_OFC1433_n8093 FE_OFN1433_n8093 n8093 CLKBUFX2TS
XFE_OFC1432_n8092 FE_OFN1432_n8092 FE_OFN1430_n8092 CLKBUFX2TS
XFE_OFC1431_n8092 FE_OFN1431_n8092 n8092 CLKBUFX2TS
XFE_OFC1430_n8092 FE_OFN1430_n8092 FE_OFN1429_n8092 CLKBUFX2TS
XFE_OFC1429_n8092 FE_OFN1429_n8092 n8092 CLKBUFX2TS
XFE_OFC1428_n8091 FE_OFN1428_n8091 FE_OFN1425_n8091 CLKBUFX2TS
XFE_OFC1427_n8091 FE_OFN1427_n8091 FE_OFN1425_n8091 CLKBUFX2TS
XFE_OFC1426_n8091 FE_OFN1426_n8091 n8091 CLKBUFX2TS
XFE_OFC1425_n8091 FE_OFN1425_n8091 n8091 CLKBUFX2TS
XFE_OFC1424_n8090 FE_OFN1424_n8090 FE_OFN1422_n8090 CLKBUFX2TS
XFE_OFC1423_n8090 FE_OFN1423_n8090 FE_OFN1422_n8090 CLKBUFX2TS
XFE_OFC1422_n8090 FE_OFN1422_n8090 FE_OFN1420_n8090 CLKBUFX2TS
XFE_OFC1421_n8090 FE_OFN1421_n8090 FE_OFN1420_n8090 CLKBUFX2TS
XFE_OFC1420_n8090 FE_OFN1420_n8090 n8090 CLKBUFX2TS
XFE_OFC1419_n8089 FE_OFN1419_n8089 FE_OFN1417_n8089 CLKBUFX2TS
XFE_OFC1418_n8089 FE_OFN1418_n8089 FE_OFN1417_n8089 CLKBUFX2TS
XFE_OFC1417_n8089 FE_OFN1417_n8089 FE_OFN1416_n8089 CLKBUFX2TS
XFE_OFC1416_n8089 FE_OFN1416_n8089 n8089 CLKBUFX2TS
XFE_OFC1415_n8088 FE_OFN1415_n8088 FE_OFN1414_n8088 CLKBUFX2TS
XFE_OFC1414_n8088 FE_OFN1414_n8088 FE_OFN1413_n8088 CLKBUFX2TS
XFE_OFC1413_n8088 FE_OFN1413_n8088 FE_OFN1412_n8088 CLKBUFX2TS
XFE_OFC1412_n8088 FE_OFN1412_n8088 n8088 CLKBUFX2TS
XFE_OFC1411_n8087 FE_OFN1411_n8087 FE_OFN1409_n8087 CLKBUFX2TS
XFE_OFC1410_n8087 FE_OFN1410_n8087 FE_OFN1409_n8087 CLKBUFX2TS
XFE_OFC1409_n8087 FE_OFN1409_n8087 FE_OFN1408_n8087 CLKBUFX2TS
XFE_OFC1408_n8087 FE_OFN1408_n8087 FE_OFN1407_n8087 CLKBUFX2TS
XFE_OFC1407_n8087 FE_OFN1407_n8087 n8087 CLKBUFX2TS
XFE_OFC1406_n8086 FE_OFN1406_n8086 FE_OFN1404_n8086 CLKBUFX2TS
XFE_OFC1405_n8086 FE_OFN1405_n8086 FE_OFN1404_n8086 CLKBUFX2TS
XFE_OFC1404_n8086 FE_OFN1404_n8086 FE_OFN1403_n8086 CLKBUFX2TS
XFE_OFC1403_n8086 FE_OFN1403_n8086 n8086 CLKBUFX2TS
XFE_OFC1402_n8085 FE_OFN1402_n8085 FE_OFN1401_n8085 CLKBUFX2TS
XFE_OFC1401_n8085 FE_OFN1401_n8085 FE_OFN1400_n8085 CLKBUFX2TS
XFE_OFC1400_n8085 FE_OFN1400_n8085 FE_OFN1399_n8085 CLKBUFX2TS
XFE_OFC1399_n8085 FE_OFN1399_n8085 n8085 CLKBUFX2TS
XFE_OFC1398_n8084 FE_OFN1398_n8084 FE_OFN1397_n8084 CLKBUFX2TS
XFE_OFC1397_n8084 FE_OFN1397_n8084 FE_OFN1396_n8084 CLKBUFX2TS
XFE_OFC1396_n8084 FE_OFN1396_n8084 FE_OFN1395_n8084 CLKBUFX2TS
XFE_OFC1395_n8084 FE_OFN1395_n8084 FE_OFN1394_n8084 CLKBUFX2TS
XFE_OFC1394_n8084 FE_OFN1394_n8084 n8084 CLKBUFX2TS
XFE_OFC1393_n8083 FE_OFN1393_n8083 FE_OFN1391_n8083 CLKBUFX2TS
XFE_OFC1392_n8083 FE_OFN1392_n8083 FE_OFN1391_n8083 CLKBUFX2TS
XFE_OFC1391_n8083 FE_OFN1391_n8083 FE_OFN1390_n8083 CLKBUFX2TS
XFE_OFC1390_n8083 FE_OFN1390_n8083 n8083 CLKBUFX2TS
XFE_OFC1389_n8083 FE_OFN1389_n8083 n8083 CLKBUFX2TS
XFE_OFC1388_n8082 FE_OFN1388_n8082 FE_OFN1387_n8082 CLKBUFX2TS
XFE_OFC1387_n8082 FE_OFN1387_n8082 FE_OFN1385_n8082 CLKBUFX2TS
XFE_OFC1386_n8082 FE_OFN1386_n8082 FE_OFN1384_n8082 CLKBUFX2TS
XFE_OFC1385_n8082 FE_OFN1385_n8082 n8082 CLKBUFX2TS
XFE_OFC1384_n8082 FE_OFN1384_n8082 n8082 CLKBUFX2TS
XFE_OFC1383_n8081 FE_OFN1383_n8081 FE_OFN1381_n8081 CLKBUFX2TS
XFE_OFC1382_n8081 FE_OFN1382_n8081 FE_OFN1380_n8081 CLKBUFX2TS
XFE_OFC1381_n8081 FE_OFN1381_n8081 n8081 CLKBUFX2TS
XFE_OFC1380_n8081 FE_OFN1380_n8081 n8081 CLKBUFX2TS
XFE_OFC1379_n8080 FE_OFN1379_n8080 FE_OFN1378_n8080 CLKBUFX2TS
XFE_OFC1378_n8080 FE_OFN1378_n8080 FE_OFN1376_n8080 CLKBUFX2TS
XFE_OFC1377_n8080 FE_OFN1377_n8080 n8080 CLKBUFX2TS
XFE_OFC1376_n8080 FE_OFN1376_n8080 n8080 CLKBUFX2TS
XFE_OFC1375_n8078 FE_OFN1375_n8078 FE_OFN1374_n8078 CLKBUFX2TS
XFE_OFC1374_n8078 FE_OFN1374_n8078 FE_OFN1373_n8078 CLKBUFX2TS
XFE_OFC1373_n8078 FE_OFN1373_n8078 FE_OFN1372_n8078 CLKBUFX2TS
XFE_OFC1372_n8078 FE_OFN1372_n8078 FE_OFN1371_n8078 CLKBUFX2TS
XFE_OFC1371_n8078 FE_OFN1371_n8078 n8078 CLKBUFX2TS
XFE_OFC1370_n8077 FE_OFN1370_n8077 FE_OFN1369_n8077 CLKBUFX2TS
XFE_OFC1369_n8077 FE_OFN1369_n8077 FE_OFN1367_n8077 CLKBUFX2TS
XFE_OFC1368_n8077 FE_OFN1368_n8077 FE_OFN1367_n8077 CLKBUFX2TS
XFE_OFC1367_n8077 FE_OFN1367_n8077 FE_OFN1366_n8077 CLKBUFX2TS
XFE_OFC1366_n8077 FE_OFN1366_n8077 n8077 CLKBUFX2TS
XFE_OFC1365_n8076 FE_OFN1365_n8076 FE_OFN1364_n8076 CLKBUFX2TS
XFE_OFC1364_n8076 FE_OFN1364_n8076 FE_OFN1363_n8076 CLKBUFX2TS
XFE_OFC1363_n8076 FE_OFN1363_n8076 FE_OFN1362_n8076 CLKBUFX2TS
XFE_OFC1362_n8076 FE_OFN1362_n8076 n8076 CLKBUFX2TS
XFE_OFC1361_n8075 FE_OFN1361_n8075 FE_OFN1360_n8075 CLKBUFX2TS
XFE_OFC1360_n8075 FE_OFN1360_n8075 FE_OFN1358_n8075 CLKBUFX2TS
XFE_OFC1359_n8075 FE_OFN1359_n8075 FE_OFN1358_n8075 CLKBUFX2TS
XFE_OFC1358_n8075 FE_OFN1358_n8075 FE_OFN1357_n8075 CLKBUFX2TS
XFE_OFC1357_n8075 FE_OFN1357_n8075 n8075 CLKBUFX2TS
XFE_OFC1356_n8074 FE_OFN1356_n8074 FE_OFN1355_n8074 CLKBUFX2TS
XFE_OFC1355_n8074 FE_OFN1355_n8074 FE_OFN1354_n8074 CLKBUFX2TS
XFE_OFC1354_n8074 FE_OFN1354_n8074 FE_OFN1353_n8074 CLKBUFX2TS
XFE_OFC1353_n8074 FE_OFN1353_n8074 n8074 CLKBUFX2TS
XFE_OFC1352_n8073 FE_OFN1352_n8073 FE_OFN1351_n8073 CLKBUFX2TS
XFE_OFC1351_n8073 FE_OFN1351_n8073 FE_OFN1350_n8073 CLKBUFX2TS
XFE_OFC1350_n8073 FE_OFN1350_n8073 n8073 CLKBUFX2TS
XFE_OFC1349_n8073 FE_OFN1349_n8073 n8073 CLKBUFX2TS
XFE_OFC1348_n8072 FE_OFN1348_n8072 FE_OFN1347_n8072 CLKBUFX2TS
XFE_OFC1347_n8072 FE_OFN1347_n8072 FE_OFN1345_n8072 CLKBUFX2TS
XFE_OFC1346_n8072 FE_OFN1346_n8072 FE_OFN1345_n8072 CLKBUFX2TS
XFE_OFC1345_n8072 FE_OFN1345_n8072 FE_OFN1344_n8072 CLKBUFX2TS
XFE_OFC1344_n8072 FE_OFN1344_n8072 n8072 CLKBUFX2TS
XFE_OFC1343_n8071 FE_OFN1343_n8071 FE_OFN1342_n8071 CLKBUFX2TS
XFE_OFC1342_n8071 FE_OFN1342_n8071 FE_OFN1341_n8071 CLKBUFX2TS
XFE_OFC1341_n8071 FE_OFN1341_n8071 FE_OFN1340_n8071 CLKBUFX2TS
XFE_OFC1340_n8071 FE_OFN1340_n8071 FE_OFN1339_n8071 CLKBUFX2TS
XFE_OFC1339_n8071 FE_OFN1339_n8071 n8071 CLKBUFX2TS
XFE_OFC1338_n8070 FE_OFN1338_n8070 FE_OFN1337_n8070 CLKBUFX2TS
XFE_OFC1337_n8070 FE_OFN1337_n8070 FE_OFN1336_n8070 CLKBUFX2TS
XFE_OFC1336_n8070 FE_OFN1336_n8070 FE_OFN1335_n8070 CLKBUFX2TS
XFE_OFC1335_n8070 FE_OFN1335_n8070 n8070 CLKBUFX2TS
XFE_OFC1334_n8069 FE_OFN1334_n8069 FE_OFN1333_n8069 CLKBUFX2TS
XFE_OFC1333_n8069 FE_OFN1333_n8069 FE_OFN1332_n8069 CLKBUFX2TS
XFE_OFC1332_n8069 FE_OFN1332_n8069 FE_OFN1331_n8069 CLKBUFX2TS
XFE_OFC1331_n8069 FE_OFN1331_n8069 n8069 CLKBUFX2TS
XFE_OFC1330_n8068 FE_OFN1330_n8068 FE_OFN1329_n8068 CLKBUFX2TS
XFE_OFC1329_n8068 FE_OFN1329_n8068 FE_OFN1328_n8068 CLKBUFX2TS
XFE_OFC1328_n8068 FE_OFN1328_n8068 FE_OFN1327_n8068 CLKBUFX2TS
XFE_OFC1327_n8068 FE_OFN1327_n8068 n8068 CLKBUFX2TS
XFE_OFC1326_n8067 FE_OFN1326_n8067 FE_OFN1324_n8067 CLKBUFX2TS
XFE_OFC1325_n8067 FE_OFN1325_n8067 FE_OFN1324_n8067 CLKBUFX2TS
XFE_OFC1324_n8067 FE_OFN1324_n8067 FE_OFN1323_n8067 CLKBUFX2TS
XFE_OFC1323_n8067 FE_OFN1323_n8067 n8067 CLKBUFX2TS
XFE_OFC1322_n8066 FE_OFN1322_n8066 FE_OFN1321_n8066 CLKBUFX2TS
XFE_OFC1321_n8066 FE_OFN1321_n8066 FE_OFN1320_n8066 CLKBUFX2TS
XFE_OFC1320_n8066 FE_OFN1320_n8066 FE_OFN1319_n8066 CLKBUFX2TS
XFE_OFC1319_n8066 FE_OFN1319_n8066 FE_OFN1318_n8066 CLKBUFX2TS
XFE_OFC1318_n8066 FE_OFN1318_n8066 n8066 CLKBUFX2TS
XFE_OFC1317_n8065 FE_OFN1317_n8065 FE_OFN1316_n8065 CLKBUFX2TS
XFE_OFC1316_n8065 FE_OFN1316_n8065 FE_OFN1315_n8065 CLKBUFX2TS
XFE_OFC1315_n8065 FE_OFN1315_n8065 FE_OFN1314_n8065 CLKBUFX2TS
XFE_OFC1314_n8065 FE_OFN1314_n8065 n8065 CLKBUFX2TS
XFE_OFC1313_n8094 FE_OFN1313_n8094 FE_OFN1310_n8094 CLKBUFX2TS
XFE_OFC1312_n8094 FE_OFN1312_n8094 FE_OFN1311_n8094 CLKBUFX2TS
XFE_OFC1311_n8094 FE_OFN1311_n8094 n8094 CLKBUFX2TS
XFE_OFC1310_n8094 FE_OFN1310_n8094 n8094 CLKBUFX2TS
XFE_OFC1309_n8079 FE_OFN1309_n8079 FE_OFN1308_n8079 CLKBUFX2TS
XFE_OFC1308_n8079 FE_OFN1308_n8079 FE_OFN1307_n8079 CLKBUFX2TS
XFE_OFC1307_n8079 FE_OFN1307_n8079 FE_OFN1306_n8079 CLKBUFX2TS
XFE_OFC1306_n8079 FE_OFN1306_n8079 n8079 CLKBUFX2TS
XFE_OFC1305_n8060 FE_OFN1305_n8060 FE_OFN1304_n8060 CLKBUFX2TS
XFE_OFC1304_n8060 FE_OFN1304_n8060 FE_OFN1302_n8060 CLKBUFX2TS
XFE_OFC1303_n8060 FE_OFN1303_n8060 FE_OFN1302_n8060 CLKBUFX2TS
XFE_OFC1302_n8060 FE_OFN1302_n8060 FE_OFN1301_n8060 CLKBUFX2TS
XFE_OFC1301_n8060 FE_OFN1301_n8060 n8060 CLKBUFX2TS
XFE_OFC1300_iir_enable FE_OFN1300_iir_enable FE_OFN1299_iir_enable CLKBUFX2TS
XFE_OFC1299_iir_enable FE_OFN1299_iir_enable FE_OFN1298_iir_enable CLKBUFX2TS
XFE_OFC1298_iir_enable FE_OFN1298_iir_enable FE_OFN1294_iir_enable CLKBUFX2TS
XFE_OFC1297_iir_enable FE_OFN1297_iir_enable FE_OFN1294_iir_enable CLKBUFX2TS
XFE_OFC1296_iir_enable FE_OFN1296_iir_enable FE_OFN1293_iir_enable CLKBUFX2TS
XFE_OFC1295_iir_enable FE_OFN1295_iir_enable FE_OFN1293_iir_enable CLKBUFX2TS
XFE_OFC1294_iir_enable FE_OFN1294_iir_enable FE_OFN1292_iir_enable CLKBUFX2TS
XFE_OFC1293_iir_enable FE_OFN1293_iir_enable FE_OFN1291_iir_enable CLKBUFX2TS
XFE_OFC1292_iir_enable FE_OFN1292_iir_enable FE_OFN1290_iir_enable CLKBUFX2TS
XFE_OFC1291_iir_enable FE_OFN1291_iir_enable FE_OFN1290_iir_enable CLKBUFX2TS
XFE_OFC1290_iir_enable FE_OFN1290_iir_enable FE_OFN1288_iir_enable CLKBUFX2TS
XFE_OFC1289_iir_enable FE_OFN1289_iir_enable FE_OFN1288_iir_enable CLKBUFX2TS
XFE_OFC1288_iir_enable FE_OFN1288_iir_enable FE_OFN1287_iir_enable CLKBUFX2TS
XFE_OFC1287_iir_enable FE_OFN1287_iir_enable FE_OFN1286_iir_enable CLKBUFX2TS
XFE_OFC1286_iir_enable FE_OFN1286_iir_enable iir_enable CLKBUFX2TS
XFE_OFC1285_router_ram_read_enable_reg FE_OFN1285_router_ram_read_enable_reg
+ FE_OFN1284_router_ram_read_enable_reg CLKBUFX2TS
XFE_OFC1284_router_ram_read_enable_reg FE_OFN1284_router_ram_read_enable_reg
+ router_ram_read_enable_reg CLKBUFX2TS
XFE_OFC1283_router_fft_write_done FE_OFN1283_router_fft_write_done
+ router_fft_write_done CLKBUFX2TS
XFE_OFC1282_router_fft_get_req_reg FE_OFN1282_router_fft_get_req_reg
+ router_fft_get_req_reg CLKBUFX2TS
XFE_OFC1281_router_addr_calc_iir_write_calc_count_5_
+ FE_OFN1281_router_addr_calc_iir_write_calc_count_5_
+ router_addr_calc_iir_write_calc_count[5] CLKBUFX2TS
XFE_OFC1280_router_addr_calc_iir_write_calc_count_9_
+ FE_OFN1280_router_addr_calc_iir_write_calc_count_9_
+ router_addr_calc_iir_write_calc_count[9] CLKBUFX2TS
XFE_OFC1279_n7328 FE_OFN1279_n7328 n7328 CLKBUFX2TS
XFE_OFC1278_n7333 FE_OFN1278_n7333 n7333 CLKBUFX2TS
XFE_OFC1277_n7308 FE_OFN1277_n7308 n7308 CLKBUFX2TS
XFE_OFC1276_router_addr_calc_fir_read_calc_count_5_
+ FE_OFN1276_router_addr_calc_fir_read_calc_count_5_
+ FE_OFN1824_router_addr_calc_fir_read_calc_count_5_ CLKBUFX2TS
XFE_OFC1275_n7353 FE_OFN1275_n7353 n7353 CLKBUFX2TS
XFE_OFC1274_n7358 FE_OFN1274_n7358 n7358 CLKBUFX2TS
XFE_OFC1273_router_addr_calc_fft_read_calc_count_5_
+ FE_OFN1273_router_addr_calc_fft_read_calc_count_5_
+ router_addr_calc_fft_read_calc_count[5] CLKBUFX2TS
XFE_OFC1272_router_addr_calc_fir_write_calc_count_5_
+ FE_OFN1272_router_addr_calc_fir_write_calc_count_5_
+ router_addr_calc_fir_write_calc_count[5] CLKBUFX2TS
XFE_OFC1271_router_addr_calc_fir_read_calc_count_15_
+ FE_OFN1271_router_addr_calc_fir_read_calc_count_15_
+ router_addr_calc_fir_read_calc_count[15] CLKBUFX2TS
XFE_OFC1270_router_addr_calc_fft_write_calc_count_15_
+ FE_OFN1270_router_addr_calc_fft_write_calc_count_15_
+ router_addr_calc_fft_write_calc_count[15] CLKBUFX2TS
XFE_OFC1269_router_addr_calc_fir_read_calc_count_9_
+ FE_OFN1269_router_addr_calc_fir_read_calc_count_9_
+ router_addr_calc_fir_read_calc_count[9] CLKBUFX2TS
XFE_OFC1268_router_addr_calc_fft_write_calc_count_9_
+ FE_OFN1268_router_addr_calc_fft_write_calc_count_9_
+ router_addr_calc_fft_write_calc_count[9] CLKBUFX2TS
XFE_OFC1267_router_addr_calc_fft_read_calc_count_9_
+ FE_OFN1267_router_addr_calc_fft_read_calc_count_9_
+ router_addr_calc_fft_read_calc_count[9] CLKBUFX2TS
XFE_OFC1266_router_addr_calc_fir_write_calc_count_9_
+ FE_OFN1266_router_addr_calc_fir_write_calc_count_9_
+ router_addr_calc_fir_write_calc_count[9] CLKBUFX2TS
XFE_OFC1265_n7303 FE_OFN1265_n7303 n7303 CLKBUFX2TS
XFE_OFC1264_router_addr_calc_fir_write_calc_count_16_
+ FE_OFN1264_router_addr_calc_fir_write_calc_count_16_
+ router_addr_calc_fir_write_calc_count[16] CLKBUFX2TS
XFE_OFC1263_router_addr_calc_fft_read_calc_count_16_
+ FE_OFN1263_router_addr_calc_fft_read_calc_count_16_
+ router_addr_calc_fft_read_calc_count[16] CLKBUFX2TS
XFE_OFC1262_n7298 FE_OFN1262_n7298 n7298 CLKBUFX2TS
XFE_OFC1261_router_addr_calc_fir_write_calc_count_19_
+ FE_OFN1261_router_addr_calc_fir_write_calc_count_19_
+ router_addr_calc_fir_write_calc_count[19] CLKBUFX2TS
XFE_OFC1260_router_addr_calc_fir_read_calc_count_19_
+ FE_OFN1260_router_addr_calc_fir_read_calc_count_19_
+ router_addr_calc_fir_read_calc_count[19] CLKBUFX2TS
XFE_OFC1259_router_addr_calc_fft_write_calc_count_19_
+ FE_OFN1259_router_addr_calc_fft_write_calc_count_19_
+ router_addr_calc_fft_write_calc_count[19] CLKBUFX2TS
XFE_OFC1258_router_addr_calc_fft_read_calc_count_19_
+ FE_OFN1258_router_addr_calc_fft_read_calc_count_19_
+ router_addr_calc_fft_read_calc_count[19] CLKBUFX2TS
XFE_OFC1257_n7165 FE_OFN1257_n7165 n7165 CLKBUFX2TS
XFE_OFC1256_n7288 FE_OFN1256_n7288 n7288 CLKBUFX2TS
XFE_OFC1255_n7402 FE_OFN1255_n7402 n7402 CLKBUFX2TS
XFE_OFC1254_n7159 FE_OFN1254_n7159 n7159 CLKBUFX2TS
XFE_OFC1253_n7283 FE_OFN1253_n7283 n7283 CLKBUFX2TS
XFE_OFC1252_n7397 FE_OFN1252_n7397 n7397 CLKBUFX2TS
XFE_OFC1251_n7153 FE_OFN1251_n7153 n7153 CLKBUFX2TS
XFE_OFC1250_n7278 FE_OFN1250_n7278 n7278 CLKBUFX2TS
XFE_OFC1249_n7392 FE_OFN1249_n7392 n7392 CLKBUFX2TS
XFE_OFC1248_router_addr_calc_fir_write_calc_count_23_
+ FE_OFN1248_router_addr_calc_fir_write_calc_count_23_
+ router_addr_calc_fir_write_calc_count[23] CLKBUFX2TS
XFE_OFC1247_router_addr_calc_fir_read_calc_count_23_
+ FE_OFN1247_router_addr_calc_fir_read_calc_count_23_
+ router_addr_calc_fir_read_calc_count[23] CLKBUFX2TS
XFE_OFC1246_router_addr_calc_fft_write_calc_count_23_
+ FE_OFN1246_router_addr_calc_fft_write_calc_count_23_
+ router_addr_calc_fft_write_calc_count[23] CLKBUFX2TS
XFE_OFC1245_router_addr_calc_fft_read_calc_count_23_
+ FE_OFN1245_router_addr_calc_fft_read_calc_count_23_
+ router_addr_calc_fft_read_calc_count[23] CLKBUFX2TS
XFE_OFC1244_router_addr_calc_iir_write_calc_count_23_
+ FE_OFN1244_router_addr_calc_iir_write_calc_count_23_
+ router_addr_calc_iir_write_calc_count[23] CLKBUFX2TS
XFE_OFC1243_n7273 FE_OFN1243_n7273 n7273 CLKBUFX2TS
XFE_OFC1242_n7268 FE_OFN1242_n7268 n7268 CLKBUFX2TS
XFE_OFC1241_n7264 FE_OFN1241_n7264 n7264 CLKBUFX2TS
XFE_OFC1240_router_addr_calc_fir_write_calc_count_27_
+ FE_OFN1240_router_addr_calc_fir_write_calc_count_27_
+ router_addr_calc_fir_write_calc_count[27] CLKBUFX2TS
XFE_OFC1239_router_addr_calc_fir_read_calc_count_27_
+ FE_OFN1239_router_addr_calc_fir_read_calc_count_27_
+ router_addr_calc_fir_read_calc_count[27] CLKBUFX2TS
XFE_OFC1238_router_addr_calc_fft_write_calc_count_27_
+ FE_OFN1238_router_addr_calc_fft_write_calc_count_27_
+ router_addr_calc_fft_write_calc_count[27] CLKBUFX2TS
XFE_OFC1237_router_addr_calc_fft_read_calc_count_27_
+ FE_OFN1237_router_addr_calc_fft_read_calc_count_27_
+ router_addr_calc_fft_read_calc_count[27] CLKBUFX2TS
XFE_OFC1236_n7259 FE_OFN1236_n7259 n7259 CLKBUFX2TS
XFE_OFC1235_n7254 FE_OFN1235_n7254 n7254 CLKBUFX2TS
XFE_OFC1234_n7492 FE_OFN1234_n7492 n7492 CLKBUFX2TS
XFE_OFC1233_router_addr_calc_fft_write_calc_count_29_
+ FE_OFN1233_router_addr_calc_fft_write_calc_count_29_
+ router_addr_calc_fft_write_calc_count[29] CLKBUFX2TS
XFE_OFC1232_n7368 FE_OFN1232_n7368 n7368 CLKBUFX2TS
XFE_OFC1231_router_addr_calc_fir_write_calc_count_30_
+ FE_OFN1231_router_addr_calc_fir_write_calc_count_30_
+ router_addr_calc_fir_write_calc_count[30] CLKBUFX2TS
XFE_OFC1230_router_addr_calc_fir_read_calc_count_30_
+ FE_OFN1230_router_addr_calc_fir_read_calc_count_30_
+ router_addr_calc_fir_read_calc_count[30] CLKBUFX2TS
XFE_OFC1229_router_addr_calc_fft_read_calc_count_30_
+ FE_OFN1229_router_addr_calc_fft_read_calc_count_30_
+ router_addr_calc_fft_read_calc_count[30] CLKBUFX2TS
XFE_OFC1228_router_addr_calc_fft_write_calc_count_31_
+ FE_OFN1228_router_addr_calc_fft_write_calc_count_31_
+ router_addr_calc_fft_write_calc_count[31] CLKBUFX2TS
XFE_OFC1227_n8063 FE_OFN1227_n8063 FE_OFN1226_n8063 CLKBUFX2TS
XFE_OFC1226_n8063 FE_OFN1226_n8063 FE_OFN1225_n8063 CLKBUFX2TS
XFE_OFC1225_n8063 FE_OFN1225_n8063 FE_OFN1223_n8063 CLKBUFX2TS
XFE_OFC1224_n8063 FE_OFN1224_n8063 n8063 CLKBUFX2TS
XFE_OFC1223_n8063 FE_OFN1223_n8063 n8063 CLKBUFX2TS
XFE_OFC1222_n8064 FE_OFN1222_n8064 FE_OFN1221_n8064 CLKBUFX2TS
XFE_OFC1221_n8064 FE_OFN1221_n8064 FE_OFN1219_n8064 CLKBUFX2TS
XFE_OFC1220_n8064 FE_OFN1220_n8064 FE_OFN1219_n8064 CLKBUFX2TS
XFE_OFC1219_n8064 FE_OFN1219_n8064 FE_OFN1218_n8064 CLKBUFX2TS
XFE_OFC1218_n8064 FE_OFN1218_n8064 n8064 CLKBUFX2TS
XFE_OFC1217_n3478 FE_OFN1217_n3478 n3478 CLKBUFX2TS
XFE_OFC1216_n8061 FE_OFN1216_n8061 FE_OFN1215_n8061 CLKBUFX2TS
XFE_OFC1215_n8061 FE_OFN1215_n8061 FE_OFN1214_n8061 CLKBUFX2TS
XFE_OFC1214_n8061 FE_OFN1214_n8061 FE_OFN1212_n8061 CLKBUFX2TS
XFE_OFC1213_n8061 FE_OFN1213_n8061 FE_OFN1212_n8061 CLKBUFX2TS
XFE_OFC1212_n8061 FE_OFN1212_n8061 n8061 CLKBUFX2TS
XFE_OFC1211_n8062 FE_OFN1211_n8062 FE_OFN1209_n8062 CLKBUFX2TS
XFE_OFC1210_n8062 FE_OFN1210_n8062 FE_OFN1209_n8062 CLKBUFX2TS
XFE_OFC1209_n8062 FE_OFN1209_n8062 FE_OFN1208_n8062 CLKBUFX2TS
XFE_OFC1208_n8062 FE_OFN1208_n8062 n8062 CLKBUFX2TS
XFE_OFC1207_router_addr_calc_iir_write_calc_counter_N212
+ FE_OFN1207_router_addr_calc_iir_write_calc_counter_N212
+ FE_OFN1206_router_addr_calc_iir_write_calc_counter_N212 CLKBUFX2TS
XFE_OFC1206_router_addr_calc_iir_write_calc_counter_N212
+ FE_OFN1206_router_addr_calc_iir_write_calc_counter_N212
+ FE_OFN1204_router_addr_calc_iir_write_calc_counter_N212 CLKBUFX2TS
XFE_OFC1205_router_addr_calc_iir_write_calc_counter_N212
+ FE_OFN1205_router_addr_calc_iir_write_calc_counter_N212
+ FE_OFN1203_router_addr_calc_iir_write_calc_counter_N212 CLKBUFX2TS
XFE_OFC1204_router_addr_calc_iir_write_calc_counter_N212
+ FE_OFN1204_router_addr_calc_iir_write_calc_counter_N212
+ FE_OFN1203_router_addr_calc_iir_write_calc_counter_N212 CLKBUFX2TS
XFE_OFC1203_router_addr_calc_iir_write_calc_counter_N212
+ FE_OFN1203_router_addr_calc_iir_write_calc_counter_N212
+ FE_OFN1202_router_addr_calc_iir_write_calc_counter_N212 CLKBUFX2TS
XFE_OFC1202_router_addr_calc_iir_write_calc_counter_N212
+ FE_OFN1202_router_addr_calc_iir_write_calc_counter_N212
+ FE_OFN1201_router_addr_calc_iir_write_calc_counter_N212 CLKBUFX2TS
XFE_OFC1201_router_addr_calc_iir_write_calc_counter_N212
+ FE_OFN1201_router_addr_calc_iir_write_calc_counter_N212
+ FE_OFN1200_router_addr_calc_iir_write_calc_counter_N212 CLKBUFX2TS
XFE_OFC1200_router_addr_calc_iir_write_calc_counter_N212
+ FE_OFN1200_router_addr_calc_iir_write_calc_counter_N212
+ FE_OFN1199_router_addr_calc_iir_write_calc_counter_N212 CLKBUFX2TS
XFE_OFC1199_router_addr_calc_iir_write_calc_counter_N212
+ FE_OFN1199_router_addr_calc_iir_write_calc_counter_N212
+ router_addr_calc_iir_write_calc_counter_N212 CLKBUFX2TS
XFE_OFC1198_n7023 FE_OFN1198_n7023 FE_OFN1197_n7023 CLKBUFX2TS
XFE_OFC1197_n7023 FE_OFN1197_n7023 FE_OFN1196_n7023 CLKBUFX2TS
XFE_OFC1196_n7023 FE_OFN1196_n7023 FE_OFN1195_n7023 CLKBUFX2TS
XFE_OFC1195_n7023 FE_OFN1195_n7023 FE_OFN1194_n7023 CLKBUFX2TS
XFE_OFC1194_n7023 FE_OFN1194_n7023 FE_OFN1193_n7023 CLKBUFX2TS
XFE_OFC1193_n7023 FE_OFN1193_n7023 n7023 CLKBUFX2TS
XFE_OFC1192_n7022 FE_OFN1192_n7022 FE_OFN1190_n7022 CLKBUFX2TS
XFE_OFC1191_n7022 FE_OFN1191_n7022 n7022 CLKBUFX2TS
XFE_OFC1190_n7022 FE_OFN1190_n7022 n7022 CLKBUFX2TS
XFE_OFC1189_n7020 FE_OFN1189_n7020 FE_OFN1186_n7020 CLKBUFX2TS
XFE_OFC1188_n7020 FE_OFN1188_n7020 FE_OFN1187_n7020 CLKBUFX2TS
XFE_OFC1187_n7020 FE_OFN1187_n7020 FE_OFN1184_n7020 CLKBUFX2TS
XFE_OFC1186_n7020 FE_OFN1186_n7020 FE_OFN1185_n7020 CLKBUFX2TS
XFE_OFC1185_n7020 FE_OFN1185_n7020 FE_OFN1182_n7020 CLKBUFX2TS
XFE_OFC1184_n7020 FE_OFN1184_n7020 FE_OFN1183_n7020 CLKBUFX2TS
XFE_OFC1183_n7020 FE_OFN1183_n7020 FE_OFN1181_n7020 CLKBUFX2TS
XFE_OFC1182_n7020 FE_OFN1182_n7020 FE_OFN1180_n7020 CLKBUFX2TS
XFE_OFC1181_n7020 FE_OFN1181_n7020 FE_OFN1180_n7020 CLKBUFX2TS
XFE_OFC1180_n7020 FE_OFN1180_n7020 FE_OFN1179_n7020 CLKBUFX2TS
XFE_OFC1179_n7020 FE_OFN1179_n7020 n7020 CLKBUFX2TS
XFE_OFC1178_n7021 FE_OFN1178_n7021 FE_OFN1176_n7021 CLKBUFX2TS
XFE_OFC1177_n7021 FE_OFN1177_n7021 FE_OFN1175_n7021 CLKBUFX2TS
XFE_OFC1176_n7021 FE_OFN1176_n7021 FE_OFN1174_n7021 CLKBUFX2TS
XFE_OFC1175_n7021 FE_OFN1175_n7021 FE_OFN1174_n7021 CLKBUFX2TS
XFE_OFC1174_n7021 FE_OFN1174_n7021 FE_OFN1172_n7021 CLKBUFX2TS
XFE_OFC1173_n7021 FE_OFN1173_n7021 FE_OFN1172_n7021 CLKBUFX2TS
XFE_OFC1172_n7021 FE_OFN1172_n7021 FE_OFN1171_n7021 CLKBUFX2TS
XFE_OFC1171_n7021 FE_OFN1171_n7021 FE_OFN1168_n7021 CLKBUFX2TS
XFE_OFC1170_n7021 FE_OFN1170_n7021 FE_OFN1169_n7021 CLKBUFX2TS
XFE_OFC1169_n7021 FE_OFN1169_n7021 n7021 CLKBUFX2TS
XFE_OFC1168_n7021 FE_OFN1168_n7021 n7021 CLKBUFX2TS
XFE_OFC1167_n7019 FE_OFN1167_n7019 FE_OFN1164_n7019 CLKBUFX2TS
XFE_OFC1166_n7019 FE_OFN1166_n7019 FE_OFN1163_n7019 CLKBUFX2TS
XFE_OFC1165_n7019 FE_OFN1165_n7019 FE_OFN1163_n7019 CLKBUFX2TS
XFE_OFC1164_n7019 FE_OFN1164_n7019 FE_OFN1162_n7019 CLKBUFX2TS
XFE_OFC1163_n7019 FE_OFN1163_n7019 FE_OFN1160_n7019 CLKBUFX2TS
XFE_OFC1162_n7019 FE_OFN1162_n7019 FE_OFN1161_n7019 CLKBUFX2TS
XFE_OFC1161_n7019 FE_OFN1161_n7019 FE_OFN1159_n7019 CLKBUFX2TS
XFE_OFC1160_n7019 FE_OFN1160_n7019 FE_OFN1159_n7019 CLKBUFX2TS
XFE_OFC1159_n7019 FE_OFN1159_n7019 FE_OFN1158_n7019 CLKBUFX2TS
XFE_OFC1158_n7019 FE_OFN1158_n7019 n7019 CLKBUFX2TS
XFE_OFC1157_n1609 FE_OFN1157_n1609 FE_OFN1155_n1609 CLKBUFX2TS
XFE_OFC1156_n1609 FE_OFN1156_n1609 FE_OFN1154_n1609 CLKBUFX2TS
XFE_OFC1155_n1609 FE_OFN1155_n1609 FE_OFN1153_n1609 CLKBUFX2TS
XFE_OFC1154_n1609 FE_OFN1154_n1609 FE_OFN1152_n1609 CLKBUFX2TS
XFE_OFC1153_n1609 FE_OFN1153_n1609 FE_OFN1152_n1609 CLKBUFX2TS
XFE_OFC1152_n1609 FE_OFN1152_n1609 FE_OFN1151_n1609 CLKBUFX2TS
XFE_OFC1151_n1609 FE_OFN1151_n1609 FE_OFN1149_n1609 CLKBUFX2TS
XFE_OFC1150_n1609 FE_OFN1150_n1609 FE_OFN1149_n1609 CLKBUFX2TS
XFE_OFC1149_n1609 FE_OFN1149_n1609 FE_OFN1148_n1609 CLKBUFX2TS
XFE_OFC1148_n1609 FE_OFN1148_n1609 n1609 CLKBUFX2TS
XFE_OFC1147_n585 FE_OFN1147_n585 FE_OFN1146_n585 CLKBUFX2TS
XFE_OFC1146_n585 FE_OFN1146_n585 FE_OFN1145_n585 CLKBUFX2TS
XFE_OFC1145_n585 FE_OFN1145_n585 FE_OFN1142_n585 CLKBUFX2TS
XFE_OFC1144_n585 FE_OFN1144_n585 FE_OFN1140_n585 CLKBUFX2TS
XFE_OFC1143_n585 FE_OFN1143_n585 FE_OFN1141_n585 CLKBUFX2TS
XFE_OFC1142_n585 FE_OFN1142_n585 FE_OFN1140_n585 CLKBUFX2TS
XFE_OFC1141_n585 FE_OFN1141_n585 FE_OFN1138_n585 CLKBUFX2TS
XFE_OFC1140_n585 FE_OFN1140_n585 FE_OFN1139_n585 CLKBUFX2TS
XFE_OFC1139_n585 FE_OFN1139_n585 FE_OFN1138_n585 CLKBUFX2TS
XFE_OFC1138_n585 FE_OFN1138_n585 n585 CLKBUFX2TS
XFE_OFC1137_n2505 FE_OFN1137_n2505 FE_OFN1136_n2505 CLKBUFX2TS
XFE_OFC1136_n2505 FE_OFN1136_n2505 FE_OFN1134_n2505 CLKBUFX2TS
XFE_OFC1135_n2505 FE_OFN1135_n2505 FE_OFN1133_n2505 CLKBUFX2TS
XFE_OFC1134_n2505 FE_OFN1134_n2505 FE_OFN1133_n2505 CLKBUFX2TS
XFE_OFC1133_n2505 FE_OFN1133_n2505 n2505 CLKBUFX2TS
XFE_OFC1132_n2441 FE_OFN1132_n2441 FE_OFN1130_n2441 CLKBUFX2TS
XFE_OFC1131_n2441 FE_OFN1131_n2441 FE_OFN1130_n2441 CLKBUFX2TS
XFE_OFC1130_n2441 FE_OFN1130_n2441 FE_OFN1129_n2441 CLKBUFX2TS
XFE_OFC1129_n2441 FE_OFN1129_n2441 n2441 CLKBUFX2TS
XFE_OFC1128_n2377 FE_OFN1128_n2377 FE_OFN1126_n2377 CLKBUFX2TS
XFE_OFC1127_n2377 FE_OFN1127_n2377 FE_OFN1126_n2377 CLKBUFX2TS
XFE_OFC1126_n2377 FE_OFN1126_n2377 FE_OFN1125_n2377 CLKBUFX2TS
XFE_OFC1125_n2377 FE_OFN1125_n2377 FE_OFN1124_n2377 CLKBUFX2TS
XFE_OFC1124_n2377 FE_OFN1124_n2377 n2377 CLKBUFX2TS
XFE_OFC1123_n2313 FE_OFN1123_n2313 FE_OFN1122_n2313 CLKBUFX2TS
XFE_OFC1122_n2313 FE_OFN1122_n2313 FE_OFN1121_n2313 CLKBUFX2TS
XFE_OFC1121_n2313 FE_OFN1121_n2313 FE_OFN1120_n2313 CLKBUFX2TS
XFE_OFC1120_n2313 FE_OFN1120_n2313 n2313 CLKBUFX2TS
XFE_OFC1119_n2249 FE_OFN1119_n2249 FE_OFN1117_n2249 CLKBUFX2TS
XFE_OFC1118_n2249 FE_OFN1118_n2249 FE_OFN1117_n2249 CLKBUFX2TS
XFE_OFC1117_n2249 FE_OFN1117_n2249 FE_OFN1116_n2249 CLKBUFX2TS
XFE_OFC1116_n2249 FE_OFN1116_n2249 FE_OFN1115_n2249 CLKBUFX2TS
XFE_OFC1115_n2249 FE_OFN1115_n2249 n2249 CLKBUFX2TS
XFE_OFC1114_n2185 FE_OFN1114_n2185 FE_OFN1112_n2185 CLKBUFX2TS
XFE_OFC1113_n2185 FE_OFN1113_n2185 FE_OFN1111_n2185 CLKBUFX2TS
XFE_OFC1112_n2185 FE_OFN1112_n2185 n2185 CLKBUFX2TS
XFE_OFC1111_n2185 FE_OFN1111_n2185 n2185 CLKBUFX2TS
XFE_OFC1110_n2121 FE_OFN1110_n2121 FE_OFN1107_n2121 CLKBUFX2TS
XFE_OFC1109_n2121 FE_OFN1109_n2121 FE_OFN1106_n2121 CLKBUFX2TS
XFE_OFC1108_n2121 FE_OFN1108_n2121 FE_OFN1107_n2121 CLKBUFX2TS
XFE_OFC1107_n2121 FE_OFN1107_n2121 FE_OFN1106_n2121 CLKBUFX2TS
XFE_OFC1106_n2121 FE_OFN1106_n2121 n2121 CLKBUFX2TS
XFE_OFC1105_n2057 FE_OFN1105_n2057 FE_OFN1104_n2057 CLKBUFX2TS
XFE_OFC1104_n2057 FE_OFN1104_n2057 FE_OFN1103_n2057 CLKBUFX2TS
XFE_OFC1103_n2057 FE_OFN1103_n2057 FE_OFN1102_n2057 CLKBUFX2TS
XFE_OFC1102_n2057 FE_OFN1102_n2057 n2057 CLKBUFX2TS
XFE_OFC1101_n1993 FE_OFN1101_n1993 FE_OFN1100_n1993 CLKBUFX2TS
XFE_OFC1100_n1993 FE_OFN1100_n1993 FE_OFN1098_n1993 CLKBUFX2TS
XFE_OFC1099_n1993 FE_OFN1099_n1993 FE_OFN1097_n1993 CLKBUFX2TS
XFE_OFC1098_n1993 FE_OFN1098_n1993 FE_OFN1097_n1993 CLKBUFX2TS
XFE_OFC1097_n1993 FE_OFN1097_n1993 n1993 CLKBUFX2TS
XFE_OFC1096_n1929 FE_OFN1096_n1929 FE_OFN1095_n1929 CLKBUFX2TS
XFE_OFC1095_n1929 FE_OFN1095_n1929 FE_OFN1094_n1929 CLKBUFX2TS
XFE_OFC1094_n1929 FE_OFN1094_n1929 FE_OFN1093_n1929 CLKBUFX2TS
XFE_OFC1093_n1929 FE_OFN1093_n1929 n1929 CLKBUFX2TS
XFE_OFC1092_n1865 FE_OFN1092_n1865 FE_OFN1091_n1865 CLKBUFX2TS
XFE_OFC1091_n1865 FE_OFN1091_n1865 FE_OFN1090_n1865 CLKBUFX2TS
XFE_OFC1090_n1865 FE_OFN1090_n1865 FE_OFN1089_n1865 CLKBUFX2TS
XFE_OFC1089_n1865 FE_OFN1089_n1865 n1865 CLKBUFX2TS
XFE_OFC1088_n1801 FE_OFN1088_n1801 FE_OFN1087_n1801 CLKBUFX2TS
XFE_OFC1087_n1801 FE_OFN1087_n1801 FE_OFN1086_n1801 CLKBUFX2TS
XFE_OFC1086_n1801 FE_OFN1086_n1801 FE_OFN1085_n1801 CLKBUFX2TS
XFE_OFC1085_n1801 FE_OFN1085_n1801 n1801 CLKBUFX2TS
XFE_OFC1084_n1737 FE_OFN1084_n1737 FE_OFN1081_n1737 CLKBUFX2TS
XFE_OFC1083_n1737 FE_OFN1083_n1737 FE_OFN1081_n1737 CLKBUFX2TS
XFE_OFC1082_n1737 FE_OFN1082_n1737 n1737 CLKBUFX2TS
XFE_OFC1081_n1737 FE_OFN1081_n1737 n1737 CLKBUFX2TS
XFE_OFC1080_n1673 FE_OFN1080_n1673 FE_OFN1078_n1673 CLKBUFX2TS
XFE_OFC1079_n1673 FE_OFN1079_n1673 FE_OFN1077_n1673 CLKBUFX2TS
XFE_OFC1078_n1673 FE_OFN1078_n1673 FE_OFN1077_n1673 CLKBUFX2TS
XFE_OFC1077_n1673 FE_OFN1077_n1673 n1673 CLKBUFX2TS
XFE_OFC1076_n1481 FE_OFN1076_n1481 FE_OFN1075_n1481 CLKBUFX2TS
XFE_OFC1075_n1481 FE_OFN1075_n1481 FE_OFN1074_n1481 CLKBUFX2TS
XFE_OFC1074_n1481 FE_OFN1074_n1481 FE_OFN1073_n1481 CLKBUFX2TS
XFE_OFC1073_n1481 FE_OFN1073_n1481 n1481 CLKBUFX2TS
XFE_OFC1072_n1417 FE_OFN1072_n1417 FE_OFN1071_n1417 CLKBUFX2TS
XFE_OFC1071_n1417 FE_OFN1071_n1417 FE_OFN1070_n1417 CLKBUFX2TS
XFE_OFC1070_n1417 FE_OFN1070_n1417 FE_OFN1069_n1417 CLKBUFX2TS
XFE_OFC1069_n1417 FE_OFN1069_n1417 n1417 CLKBUFX2TS
XFE_OFC1068_n1353 FE_OFN1068_n1353 FE_OFN1067_n1353 CLKBUFX2TS
XFE_OFC1067_n1353 FE_OFN1067_n1353 FE_OFN1066_n1353 CLKBUFX2TS
XFE_OFC1066_n1353 FE_OFN1066_n1353 n1353 CLKBUFX2TS
XFE_OFC1065_n1353 FE_OFN1065_n1353 n1353 CLKBUFX2TS
XFE_OFC1064_n1289 FE_OFN1064_n1289 FE_OFN1063_n1289 CLKBUFX2TS
XFE_OFC1063_n1289 FE_OFN1063_n1289 FE_OFN1062_n1289 CLKBUFX2TS
XFE_OFC1062_n1289 FE_OFN1062_n1289 FE_OFN1061_n1289 CLKBUFX2TS
XFE_OFC1061_n1289 FE_OFN1061_n1289 n1289 CLKBUFX2TS
XFE_OFC1060_n1225 FE_OFN1060_n1225 FE_OFN1059_n1225 CLKBUFX2TS
XFE_OFC1059_n1225 FE_OFN1059_n1225 FE_OFN1058_n1225 CLKBUFX2TS
XFE_OFC1058_n1225 FE_OFN1058_n1225 FE_OFN1057_n1225 CLKBUFX2TS
XFE_OFC1057_n1225 FE_OFN1057_n1225 FE_OFN1056_n1225 CLKBUFX2TS
XFE_OFC1056_n1225 FE_OFN1056_n1225 n1225 CLKBUFX2TS
XFE_OFC1055_n1161 FE_OFN1055_n1161 FE_OFN1054_n1161 CLKBUFX2TS
XFE_OFC1054_n1161 FE_OFN1054_n1161 FE_OFN1053_n1161 CLKBUFX2TS
XFE_OFC1053_n1161 FE_OFN1053_n1161 FE_OFN1052_n1161 CLKBUFX2TS
XFE_OFC1052_n1161 FE_OFN1052_n1161 n1161 CLKBUFX2TS
XFE_OFC1051_n1097 FE_OFN1051_n1097 FE_OFN1050_n1097 CLKBUFX2TS
XFE_OFC1050_n1097 FE_OFN1050_n1097 FE_OFN1049_n1097 CLKBUFX2TS
XFE_OFC1049_n1097 FE_OFN1049_n1097 FE_OFN1048_n1097 CLKBUFX2TS
XFE_OFC1048_n1097 FE_OFN1048_n1097 n1097 CLKBUFX2TS
XFE_OFC1047_n1033 FE_OFN1047_n1033 FE_OFN1046_n1033 CLKBUFX2TS
XFE_OFC1046_n1033 FE_OFN1046_n1033 FE_OFN1044_n1033 CLKBUFX2TS
XFE_OFC1045_n1033 FE_OFN1045_n1033 FE_OFN1044_n1033 CLKBUFX2TS
XFE_OFC1044_n1033 FE_OFN1044_n1033 FE_OFN1043_n1033 CLKBUFX2TS
XFE_OFC1043_n1033 FE_OFN1043_n1033 n1033 CLKBUFX2TS
XFE_OFC1042_n969 FE_OFN1042_n969 FE_OFN1041_n969 CLKBUFX2TS
XFE_OFC1041_n969 FE_OFN1041_n969 FE_OFN1040_n969 CLKBUFX2TS
XFE_OFC1040_n969 FE_OFN1040_n969 FE_OFN1039_n969 CLKBUFX2TS
XFE_OFC1039_n969 FE_OFN1039_n969 n969 CLKBUFX2TS
XFE_OFC1038_n905 FE_OFN1038_n905 FE_OFN1036_n905 CLKBUFX2TS
XFE_OFC1037_n905 FE_OFN1037_n905 FE_OFN1034_n905 CLKBUFX2TS
XFE_OFC1036_n905 FE_OFN1036_n905 FE_OFN1034_n905 CLKBUFX2TS
XFE_OFC1035_n905 FE_OFN1035_n905 FE_OFN1034_n905 CLKBUFX2TS
XFE_OFC1034_n905 FE_OFN1034_n905 n905 CLKBUFX2TS
XFE_OFC1033_n841 FE_OFN1033_n841 FE_OFN1032_n841 CLKBUFX2TS
XFE_OFC1032_n841 FE_OFN1032_n841 FE_OFN1031_n841 CLKBUFX2TS
XFE_OFC1031_n841 FE_OFN1031_n841 FE_OFN1030_n841 CLKBUFX2TS
XFE_OFC1030_n841 FE_OFN1030_n841 n841 CLKBUFX2TS
XFE_OFC1029_n777 FE_OFN1029_n777 FE_OFN1027_n777 CLKBUFX2TS
XFE_OFC1028_n777 FE_OFN1028_n777 FE_OFN1027_n777 CLKBUFX2TS
XFE_OFC1027_n777 FE_OFN1027_n777 FE_OFN1026_n777 CLKBUFX2TS
XFE_OFC1026_n777 FE_OFN1026_n777 n777 CLKBUFX2TS
XFE_OFC1025_n713 FE_OFN1025_n713 FE_OFN1024_n713 CLKBUFX2TS
XFE_OFC1024_n713 FE_OFN1024_n713 FE_OFN1023_n713 CLKBUFX2TS
XFE_OFC1023_n713 FE_OFN1023_n713 FE_OFN1022_n713 CLKBUFX2TS
XFE_OFC1022_n713 FE_OFN1022_n713 n713 CLKBUFX2TS
XFE_OFC1021_n649 FE_OFN1021_n649 FE_OFN1020_n649 CLKBUFX2TS
XFE_OFC1020_n649 FE_OFN1020_n649 FE_OFN1019_n649 CLKBUFX2TS
XFE_OFC1019_n649 FE_OFN1019_n649 FE_OFN1018_n649 CLKBUFX2TS
XFE_OFC1018_n649 FE_OFN1018_n649 n649 CLKBUFX2TS
XFE_OFC1017_n2569 FE_OFN1017_n2569 FE_OFN1016_n2569 CLKBUFX2TS
XFE_OFC1016_n2569 FE_OFN1016_n2569 FE_OFN1015_n2569 CLKBUFX2TS
XFE_OFC1015_n2569 FE_OFN1015_n2569 FE_OFN1014_n2569 CLKBUFX2TS
XFE_OFC1014_n2569 FE_OFN1014_n2569 n2569 CLKBUFX2TS
XFE_OFC1013_n1545 FE_OFN1013_n1545 FE_OFN1012_n1545 CLKBUFX2TS
XFE_OFC1012_n1545 FE_OFN1012_n1545 FE_OFN1010_n1545 CLKBUFX2TS
XFE_OFC1011_n1545 FE_OFN1011_n1545 FE_OFN1010_n1545 CLKBUFX2TS
XFE_OFC1010_n1545 FE_OFN1010_n1545 FE_OFN1009_n1545 CLKBUFX2TS
XFE_OFC1009_n1545 FE_OFN1009_n1545 n1545 CLKBUFX2TS
XFE_OFC1008_n137 FE_OFN1008_n137 FE_OFN1005_n137 CLKBUFX2TS
XFE_OFC1007_n137 FE_OFN1007_n137 FE_OFN1006_n137 CLKBUFX2TS
XFE_OFC1006_n137 FE_OFN1006_n137 FE_OFN1004_n137 CLKBUFX2TS
XFE_OFC1005_n137 FE_OFN1005_n137 FE_OFN1004_n137 CLKBUFX2TS
XFE_OFC1004_n137 FE_OFN1004_n137 n137 CLKBUFX2TS
XFE_OFC1003_n521 FE_OFN1003_n521 FE_OFN1002_n521 CLKBUFX2TS
XFE_OFC1002_n521 FE_OFN1002_n521 FE_OFN1001_n521 CLKBUFX2TS
XFE_OFC1001_n521 FE_OFN1001_n521 FE_OFN1000_n521 CLKBUFX2TS
XFE_OFC1000_n521 FE_OFN1000_n521 FE_OFN999_n521 CLKBUFX2TS
XFE_OFC999_n521 FE_OFN999_n521 FE_OFN998_n521 CLKBUFX2TS
XFE_OFC998_n521 FE_OFN998_n521 FE_OFN997_n521 CLKBUFX2TS
XFE_OFC997_n521 FE_OFN997_n521 FE_OFN996_n521 CLKBUFX2TS
XFE_OFC996_n521 FE_OFN996_n521 FE_OFN995_n521 CLKBUFX2TS
XFE_OFC995_n521 FE_OFN995_n521 FE_OFN994_n521 CLKBUFX2TS
XFE_OFC994_n521 FE_OFN994_n521 n521 CLKBUFX2TS
XFE_OFC993_n9431 FE_OFN993_n9431 FE_OFN992_n9431 CLKBUFX2TS
XFE_OFC992_n9431 FE_OFN992_n9431 FE_OFN991_n9431 CLKBUFX2TS
XFE_OFC991_n9431 FE_OFN991_n9431 FE_OFN990_n9431 CLKBUFX2TS
XFE_OFC990_n9431 FE_OFN990_n9431 FE_OFN988_n9431 CLKBUFX2TS
XFE_OFC989_n9431 FE_OFN989_n9431 FE_OFN987_n9431 CLKBUFX2TS
XFE_OFC988_n9431 FE_OFN988_n9431 FE_OFN986_n9431 CLKBUFX2TS
XFE_OFC987_n9431 FE_OFN987_n9431 FE_OFN986_n9431 CLKBUFX2TS
XFE_OFC986_n9431 FE_OFN986_n9431 FE_OFN985_n9431 CLKBUFX2TS
XFE_OFC985_n9431 FE_OFN985_n9431 n9431 CLKBUFX2TS
XFE_OFC984_n9462 FE_OFN984_n9462 FE_OFN983_n9462 CLKBUFX2TS
XFE_OFC983_n9462 FE_OFN983_n9462 FE_OFN982_n9462 CLKBUFX2TS
XFE_OFC982_n9462 FE_OFN982_n9462 FE_OFN981_n9462 CLKBUFX2TS
XFE_OFC981_n9462 FE_OFN981_n9462 FE_OFN980_n9462 CLKBUFX2TS
XFE_OFC980_n9462 FE_OFN980_n9462 FE_OFN978_n9462 CLKBUFX2TS
XFE_OFC979_n9462 FE_OFN979_n9462 FE_OFN978_n9462 CLKBUFX2TS
XFE_OFC978_n9462 FE_OFN978_n9462 FE_OFN977_n9462 CLKBUFX2TS
XFE_OFC977_n9462 FE_OFN977_n9462 FE_OFN976_n9462 CLKBUFX2TS
XFE_OFC976_n9462 FE_OFN976_n9462 FE_OFN974_n9462 CLKBUFX2TS
XFE_OFC975_n9462 FE_OFN975_n9462 n9462 CLKBUFX2TS
XFE_OFC974_n9462 FE_OFN974_n9462 n9462 CLKBUFX2TS
XFE_OFC973_n7207 FE_OFN973_n7207 n7207 CLKBUFX2TS
XFE_OFC972_n3618 FE_OFN972_n3618 FE_OFN971_n3618 CLKBUFX2TS
XFE_OFC971_n3618 FE_OFN971_n3618 FE_OFN969_n3618 CLKBUFX2TS
XFE_OFC970_n3618 FE_OFN970_n3618 FE_OFN969_n3618 CLKBUFX2TS
XFE_OFC969_n3618 FE_OFN969_n3618 FE_OFN968_n3618 CLKBUFX2TS
XFE_OFC968_n3618 FE_OFN968_n3618 FE_OFN967_n3618 CLKBUFX2TS
XFE_OFC967_n3618 FE_OFN967_n3618 FE_OFN966_n3618 CLKBUFX2TS
XFE_OFC966_n3618 FE_OFN966_n3618 FE_OFN965_n3618 CLKBUFX2TS
XFE_OFC965_n3618 FE_OFN965_n3618 FE_OFN964_n3618 CLKBUFX2TS
XFE_OFC964_n3618 FE_OFN964_n3618 FE_OFN962_n3618 CLKBUFX2TS
XFE_OFC963_n3618 FE_OFN963_n3618 FE_OFN962_n3618 CLKBUFX2TS
XFE_OFC962_n3618 FE_OFN962_n3618 n3618 CLKBUFX2TS
XFE_OFC961_n5467 FE_OFN961_n5467 n5467 CLKBUFX2TS
XFE_OFC960_n3619 FE_OFN960_n3619 FE_OFN959_n3619 CLKBUFX2TS
XFE_OFC959_n3619 FE_OFN959_n3619 FE_OFN958_n3619 CLKBUFX2TS
XFE_OFC958_n3619 FE_OFN958_n3619 FE_OFN957_n3619 CLKBUFX2TS
XFE_OFC957_n3619 FE_OFN957_n3619 FE_OFN956_n3619 CLKBUFX2TS
XFE_OFC956_n3619 FE_OFN956_n3619 FE_OFN955_n3619 CLKBUFX2TS
XFE_OFC955_n3619 FE_OFN955_n3619 FE_OFN953_n3619 CLKBUFX2TS
XFE_OFC954_n3619 FE_OFN954_n3619 FE_OFN952_n3619 CLKBUFX2TS
XFE_OFC953_n3619 FE_OFN953_n3619 FE_OFN951_n3619 CLKBUFX2TS
XFE_OFC952_n3619 FE_OFN952_n3619 FE_OFN951_n3619 CLKBUFX2TS
XFE_OFC951_n3619 FE_OFN951_n3619 n3619 CLKBUFX2TS
XFE_OFC950_n3486 FE_OFN950_n3486 FE_OFN949_n3486 CLKBUFX2TS
XFE_OFC949_n3486 FE_OFN949_n3486 FE_OFN948_n3486 CLKBUFX2TS
XFE_OFC948_n3486 FE_OFN948_n3486 FE_OFN947_n3486 CLKBUFX2TS
XFE_OFC947_n3486 FE_OFN947_n3486 FE_OFN945_n3486 CLKBUFX2TS
XFE_OFC946_n3486 FE_OFN946_n3486 FE_OFN944_n3486 CLKBUFX2TS
XFE_OFC945_n3486 FE_OFN945_n3486 FE_OFN942_n3486 CLKBUFX2TS
XFE_OFC944_n3486 FE_OFN944_n3486 FE_OFN943_n3486 CLKBUFX2TS
XFE_OFC943_n3486 FE_OFN943_n3486 FE_OFN941_n3486 CLKBUFX2TS
XFE_OFC942_n3486 FE_OFN942_n3486 FE_OFN940_n3486 CLKBUFX2TS
XFE_OFC941_n3486 FE_OFN941_n3486 FE_OFN940_n3486 CLKBUFX2TS
XFE_OFC940_n3486 FE_OFN940_n3486 n3486 CLKBUFX2TS
XFE_OFC939_n3487 FE_OFN939_n3487 FE_OFN938_n3487 CLKBUFX2TS
XFE_OFC938_n3487 FE_OFN938_n3487 FE_OFN937_n3487 CLKBUFX2TS
XFE_OFC937_n3487 FE_OFN937_n3487 FE_OFN936_n3487 CLKBUFX2TS
XFE_OFC936_n3487 FE_OFN936_n3487 FE_OFN935_n3487 CLKBUFX2TS
XFE_OFC935_n3487 FE_OFN935_n3487 FE_OFN934_n3487 CLKBUFX2TS
XFE_OFC934_n3487 FE_OFN934_n3487 FE_OFN932_n3487 CLKBUFX2TS
XFE_OFC933_n3487 FE_OFN933_n3487 FE_OFN930_n3487 CLKBUFX2TS
XFE_OFC932_n3487 FE_OFN932_n3487 FE_OFN931_n3487 CLKBUFX2TS
XFE_OFC931_n3487 FE_OFN931_n3487 n3487 CLKBUFX2TS
XFE_OFC930_n3487 FE_OFN930_n3487 n3487 CLKBUFX2TS
XFE_OFC929_n3574 FE_OFN929_n3574 FE_OFN928_n3574 CLKBUFX2TS
XFE_OFC928_n3574 FE_OFN928_n3574 FE_OFN927_n3574 CLKBUFX2TS
XFE_OFC927_n3574 FE_OFN927_n3574 FE_OFN926_n3574 CLKBUFX2TS
XFE_OFC926_n3574 FE_OFN926_n3574 FE_OFN925_n3574 CLKBUFX2TS
XFE_OFC925_n3574 FE_OFN925_n3574 FE_OFN924_n3574 CLKBUFX2TS
XFE_OFC924_n3574 FE_OFN924_n3574 FE_OFN923_n3574 CLKBUFX2TS
XFE_OFC923_n3574 FE_OFN923_n3574 FE_OFN922_n3574 CLKBUFX2TS
XFE_OFC922_n3574 FE_OFN922_n3574 FE_OFN920_n3574 CLKBUFX2TS
XFE_OFC921_n3574 FE_OFN921_n3574 FE_OFN919_n3574 CLKBUFX2TS
XFE_OFC920_n3574 FE_OFN920_n3574 FE_OFN919_n3574 CLKBUFX2TS
XFE_OFC919_n3574 FE_OFN919_n3574 n3574 CLKBUFX2TS
XFE_OFC918_n3575 FE_OFN918_n3575 FE_OFN917_n3575 CLKBUFX2TS
XFE_OFC917_n3575 FE_OFN917_n3575 FE_OFN916_n3575 CLKBUFX2TS
XFE_OFC916_n3575 FE_OFN916_n3575 FE_OFN915_n3575 CLKBUFX2TS
XFE_OFC915_n3575 FE_OFN915_n3575 FE_OFN914_n3575 CLKBUFX2TS
XFE_OFC914_n3575 FE_OFN914_n3575 FE_OFN913_n3575 CLKBUFX2TS
XFE_OFC913_n3575 FE_OFN913_n3575 FE_OFN912_n3575 CLKBUFX2TS
XFE_OFC912_n3575 FE_OFN912_n3575 FE_OFN911_n3575 CLKBUFX2TS
XFE_OFC911_n3575 FE_OFN911_n3575 FE_OFN910_n3575 CLKBUFX2TS
XFE_OFC910_n3575 FE_OFN910_n3575 FE_OFN909_n3575 CLKBUFX2TS
XFE_OFC909_n3575 FE_OFN909_n3575 n3575 CLKBUFX2TS
XFE_OFC908_n3530 FE_OFN908_n3530 FE_OFN905_n3530 CLKBUFX2TS
XFE_OFC907_n3530 FE_OFN907_n3530 FE_OFN904_n3530 CLKBUFX2TS
XFE_OFC906_n3530 FE_OFN906_n3530 FE_OFN904_n3530 CLKBUFX2TS
XFE_OFC905_n3530 FE_OFN905_n3530 FE_OFN902_n3530 CLKBUFX2TS
XFE_OFC904_n3530 FE_OFN904_n3530 FE_OFN903_n3530 CLKBUFX2TS
XFE_OFC903_n3530 FE_OFN903_n3530 FE_OFN901_n3530 CLKBUFX2TS
XFE_OFC902_n3530 FE_OFN902_n3530 FE_OFN901_n3530 CLKBUFX2TS
XFE_OFC901_n3530 FE_OFN901_n3530 FE_OFN899_n3530 CLKBUFX2TS
XFE_OFC900_n3530 FE_OFN900_n3530 FE_OFN899_n3530 CLKBUFX2TS
XFE_OFC899_n3530 FE_OFN899_n3530 FE_OFN898_n3530 CLKBUFX2TS
XFE_OFC898_n3530 FE_OFN898_n3530 n3530 CLKBUFX2TS
XFE_OFC897_n3531 FE_OFN897_n3531 FE_OFN894_n3531 CLKBUFX2TS
XFE_OFC896_n3531 FE_OFN896_n3531 FE_OFN895_n3531 CLKBUFX2TS
XFE_OFC895_n3531 FE_OFN895_n3531 FE_OFN891_n3531 CLKBUFX2TS
XFE_OFC894_n3531 FE_OFN894_n3531 FE_OFN893_n3531 CLKBUFX2TS
XFE_OFC893_n3531 FE_OFN893_n3531 FE_OFN888_n3531 CLKBUFX2TS
XFE_OFC892_n3531 FE_OFN892_n3531 FE_OFN889_n3531 CLKBUFX2TS
XFE_OFC891_n3531 FE_OFN891_n3531 FE_OFN888_n3531 CLKBUFX2TS
XFE_OFC890_n3531 FE_OFN890_n3531 FE_OFN889_n3531 CLKBUFX2TS
XFE_OFC889_n3531 FE_OFN889_n3531 n3531 CLKBUFX2TS
XFE_OFC888_n3531 FE_OFN888_n3531 n3531 CLKBUFX2TS
XFE_OFC887_n3662 FE_OFN887_n3662 FE_OFN885_n3662 CLKBUFX2TS
XFE_OFC886_n3662 FE_OFN886_n3662 FE_OFN884_n3662 CLKBUFX2TS
XFE_OFC885_n3662 FE_OFN885_n3662 FE_OFN882_n3662 CLKBUFX2TS
XFE_OFC884_n3662 FE_OFN884_n3662 FE_OFN883_n3662 CLKBUFX2TS
XFE_OFC883_n3662 FE_OFN883_n3662 FE_OFN880_n3662 CLKBUFX2TS
XFE_OFC882_n3662 FE_OFN882_n3662 FE_OFN881_n3662 CLKBUFX2TS
XFE_OFC881_n3662 FE_OFN881_n3662 FE_OFN880_n3662 CLKBUFX2TS
XFE_OFC880_n3662 FE_OFN880_n3662 FE_OFN879_n3662 CLKBUFX2TS
XFE_OFC879_n3662 FE_OFN879_n3662 FE_OFN878_n3662 CLKBUFX2TS
XFE_OFC878_n3662 FE_OFN878_n3662 FE_OFN877_n3662 CLKBUFX2TS
XFE_OFC877_n3662 FE_OFN877_n3662 n3662 CLKBUFX2TS
XFE_OFC876_n3663 FE_OFN876_n3663 FE_OFN874_n3663 CLKBUFX2TS
XFE_OFC875_n3663 FE_OFN875_n3663 FE_OFN873_n3663 CLKBUFX2TS
XFE_OFC874_n3663 FE_OFN874_n3663 FE_OFN872_n3663 CLKBUFX2TS
XFE_OFC873_n3663 FE_OFN873_n3663 FE_OFN870_n3663 CLKBUFX2TS
XFE_OFC872_n3663 FE_OFN872_n3663 FE_OFN870_n3663 CLKBUFX2TS
XFE_OFC871_n3663 FE_OFN871_n3663 FE_OFN869_n3663 CLKBUFX2TS
XFE_OFC870_n3663 FE_OFN870_n3663 FE_OFN868_n3663 CLKBUFX2TS
XFE_OFC869_n3663 FE_OFN869_n3663 FE_OFN867_n3663 CLKBUFX2TS
XFE_OFC868_n3663 FE_OFN868_n3663 n3663 CLKBUFX2TS
XFE_OFC867_n3663 FE_OFN867_n3663 n3663 CLKBUFX2TS
XFE_OFC866_n7015 FE_OFN866_n7015 FE_OFN865_n7015 CLKBUFX2TS
XFE_OFC865_n7015 FE_OFN865_n7015 FE_OFN863_n7015 CLKBUFX2TS
XFE_OFC864_n7015 FE_OFN864_n7015 FE_OFN862_n7015 CLKBUFX2TS
XFE_OFC863_n7015 FE_OFN863_n7015 FE_OFN862_n7015 CLKBUFX2TS
XFE_OFC862_n7015 FE_OFN862_n7015 n7015 CLKBUFX2TS
XFE_OFC861_n7017 FE_OFN861_n7017 FE_OFN860_n7017 CLKBUFX2TS
XFE_OFC860_n7017 FE_OFN860_n7017 FE_OFN859_n7017 CLKBUFX2TS
XFE_OFC859_n7017 FE_OFN859_n7017 FE_OFN858_n7017 CLKBUFX2TS
XFE_OFC858_n7017 FE_OFN858_n7017 FE_OFN857_n7017 CLKBUFX2TS
XFE_OFC857_n7017 FE_OFN857_n7017 n7017 CLKBUFX2TS
XFE_OFC856_n7018 FE_OFN856_n7018 FE_OFN855_n7018 CLKBUFX2TS
XFE_OFC855_n7018 FE_OFN855_n7018 FE_OFN853_n7018 CLKBUFX2TS
XFE_OFC854_n7018 FE_OFN854_n7018 FE_OFN853_n7018 CLKBUFX2TS
XFE_OFC853_n7018 FE_OFN853_n7018 n7018 CLKBUFX2TS
XFE_OFC852_n7016 FE_OFN852_n7016 FE_OFN851_n7016 CLKBUFX2TS
XFE_OFC851_n7016 FE_OFN851_n7016 FE_OFN850_n7016 CLKBUFX2TS
XFE_OFC850_n7016 FE_OFN850_n7016 FE_OFN849_n7016 CLKBUFX2TS
XFE_OFC849_n7016 FE_OFN849_n7016 n7016 CLKBUFX2TS
XFE_OFC848_ram_write_enable ram_write_enable FE_OFN848_ram_write_enable
+ CLKBUFX3TS
XFE_OFC847_n7619 FE_OFN847_n7619 FE_OFN844_n7619 CLKBUFX2TS
XFE_OFC846_n7619 FE_OFN846_n7619 FE_OFN845_n7619 CLKBUFX2TS
XFE_OFC845_n7619 FE_OFN845_n7619 FE_OFN841_n7619 CLKBUFX2TS
XFE_OFC844_n7619 FE_OFN844_n7619 FE_OFN840_n7619 CLKBUFX2TS
XFE_OFC843_n7619 FE_OFN843_n7619 FE_OFN839_n7619 CLKBUFX2TS
XFE_OFC842_n7619 FE_OFN842_n7619 FE_OFN838_n7619 CLKBUFX2TS
XFE_OFC841_n7619 FE_OFN841_n7619 FE_OFN837_n7619 CLKBUFX2TS
XFE_OFC840_n7619 FE_OFN840_n7619 FE_OFN836_n7619 CLKBUFX2TS
XFE_OFC839_n7619 FE_OFN839_n7619 FE_OFN833_n7619 CLKBUFX2TS
XFE_OFC838_n7619 FE_OFN838_n7619 FE_OFN834_n7619 CLKBUFX2TS
XFE_OFC837_n7619 FE_OFN837_n7619 FE_OFN831_n7619 CLKBUFX2TS
XFE_OFC836_n7619 FE_OFN836_n7619 FE_OFN830_n7619 CLKBUFX2TS
XFE_OFC835_n7619 FE_OFN835_n7619 FE_OFN832_n7619 CLKBUFX2TS
XFE_OFC834_n7619 FE_OFN834_n7619 FE_OFN826_n7619 CLKBUFX2TS
XFE_OFC833_n7619 FE_OFN833_n7619 FE_OFN828_n7619 CLKBUFX2TS
XFE_OFC832_n7619 FE_OFN832_n7619 FE_OFN825_n7619 CLKBUFX2TS
XFE_OFC831_n7619 FE_OFN831_n7619 FE_OFN822_n7619 CLKBUFX2TS
XFE_OFC830_n7619 FE_OFN830_n7619 FE_OFN824_n7619 CLKBUFX2TS
XFE_OFC829_n7619 FE_OFN829_n7619 FE_OFN822_n7619 CLKBUFX2TS
XFE_OFC828_n7619 FE_OFN828_n7619 FE_OFN821_n7619 CLKBUFX2TS
XFE_OFC827_n7619 FE_OFN827_n7619 FE_OFN824_n7619 CLKBUFX2TS
XFE_OFC826_n7619 FE_OFN826_n7619 FE_OFN819_n7619 CLKBUFX2TS
XFE_OFC825_n7619 FE_OFN825_n7619 FE_OFN818_n7619 CLKBUFX2TS
XFE_OFC824_n7619 FE_OFN824_n7619 FE_OFN820_n7619 CLKBUFX2TS
XFE_OFC823_n7619 FE_OFN823_n7619 FE_OFN816_n7619 CLKBUFX2TS
XFE_OFC822_n7619 FE_OFN822_n7619 FE_OFN817_n7619 CLKBUFX2TS
XFE_OFC821_n7619 FE_OFN821_n7619 FE_OFN809_n7619 CLKBUFX2TS
XFE_OFC820_n7619 FE_OFN820_n7619 FE_OFN813_n7619 CLKBUFX2TS
XFE_OFC819_n7619 FE_OFN819_n7619 FE_OFN814_n7619 CLKBUFX2TS
XFE_OFC818_n7619 FE_OFN818_n7619 FE_OFN812_n7619 CLKBUFX2TS
XFE_OFC817_n7619 FE_OFN817_n7619 FE_OFN812_n7619 CLKBUFX2TS
XFE_OFC816_n7619 FE_OFN816_n7619 FE_OFN810_n7619 CLKBUFX2TS
XFE_OFC815_n7619 FE_OFN815_n7619 FE_OFN808_n7619 CLKBUFX2TS
XFE_OFC814_n7619 FE_OFN814_n7619 FE_OFN810_n7619 CLKBUFX2TS
XFE_OFC813_n7619 FE_OFN813_n7619 FE_OFN806_n7619 CLKBUFX2TS
XFE_OFC812_n7619 FE_OFN812_n7619 FE_OFN803_n7619 CLKBUFX2TS
XFE_OFC811_n7619 FE_OFN811_n7619 FE_OFN804_n7619 CLKBUFX2TS
XFE_OFC810_n7619 FE_OFN810_n7619 FE_OFN805_n7619 CLKBUFX2TS
XFE_OFC809_n7619 FE_OFN809_n7619 FE_OFN804_n7619 CLKBUFX2TS
XFE_OFC808_n7619 FE_OFN808_n7619 FE_OFN803_n7619 CLKBUFX2TS
XFE_OFC807_n7619 FE_OFN807_n7619 FE_OFN803_n7619 CLKBUFX2TS
XFE_OFC806_n7619 FE_OFN806_n7619 FE_OFN801_n7619 CLKBUFX2TS
XFE_OFC805_n7619 FE_OFN805_n7619 FE_OFN798_n7619 CLKBUFX2TS
XFE_OFC804_n7619 FE_OFN804_n7619 FE_OFN799_n7619 CLKBUFX2TS
XFE_OFC803_n7619 FE_OFN803_n7619 FE_OFN795_n7619 CLKBUFX2TS
XFE_OFC802_n7619 FE_OFN802_n7619 FE_OFN796_n7619 CLKBUFX2TS
XFE_OFC801_n7619 FE_OFN801_n7619 FE_OFN796_n7619 CLKBUFX2TS
XFE_OFC800_n7619 FE_OFN800_n7619 FE_OFN790_n7619 CLKBUFX2TS
XFE_OFC799_n7619 FE_OFN799_n7619 FE_OFN793_n7619 CLKBUFX2TS
XFE_OFC798_n7619 FE_OFN798_n7619 FE_OFN794_n7619 CLKBUFX2TS
XFE_OFC797_n7619 FE_OFN797_n7619 FE_OFN794_n7619 CLKBUFX2TS
XFE_OFC796_n7619 FE_OFN796_n7619 FE_OFN792_n7619 CLKBUFX2TS
XFE_OFC795_n7619 FE_OFN795_n7619 FE_OFN791_n7619 CLKBUFX2TS
XFE_OFC794_n7619 FE_OFN794_n7619 FE_OFN792_n7619 CLKBUFX2TS
XFE_OFC793_n7619 FE_OFN793_n7619 FE_OFN788_n7619 CLKBUFX2TS
XFE_OFC792_n7619 FE_OFN792_n7619 FE_OFN786_n7619 CLKBUFX2TS
XFE_OFC791_n7619 FE_OFN791_n7619 FE_OFN789_n7619 CLKBUFX2TS
XFE_OFC790_n7619 FE_OFN790_n7619 FE_OFN787_n7619 CLKBUFX2TS
XFE_OFC789_n7619 FE_OFN789_n7619 FE_OFN785_n7619 CLKBUFX2TS
XFE_OFC788_n7619 FE_OFN788_n7619 FE_OFN784_n7619 CLKBUFX2TS
XFE_OFC787_n7619 FE_OFN787_n7619 FE_OFN782_n7619 CLKBUFX2TS
XFE_OFC786_n7619 FE_OFN786_n7619 FE_OFN783_n7619 CLKBUFX2TS
XFE_OFC785_n7619 FE_OFN785_n7619 FE_OFN781_n7619 CLKBUFX2TS
XFE_OFC784_n7619 FE_OFN784_n7619 FE_OFN781_n7619 CLKBUFX2TS
XFE_OFC783_n7619 FE_OFN783_n7619 FE_OFN780_n7619 CLKBUFX2TS
XFE_OFC782_n7619 FE_OFN782_n7619 FE_OFN780_n7619 CLKBUFX2TS
XFE_OFC781_n7619 FE_OFN781_n7619 FE_OFN777_n7619 CLKBUFX2TS
XFE_OFC780_n7619 FE_OFN780_n7619 FE_OFN778_n7619 CLKBUFX2TS
XFE_OFC779_n7619 FE_OFN779_n7619 FE_OFN778_n7619 CLKBUFX2TS
XFE_OFC778_n7619 FE_OFN778_n7619 n7619 CLKBUFX2TS
XFE_OFC777_n7619 FE_OFN777_n7619 n7619 CLKBUFX2TS
XFE_OFC776_n3829 FE_OFN776_n3829 n3829 CLKBUFX2TS
XFE_OFC775_n3720 FE_OFN775_n3720 FE_OFN774_n3720 CLKBUFX2TS
XFE_OFC774_n3720 FE_OFN774_n3720 FE_OFN772_n3720 CLKBUFX2TS
XFE_OFC773_n3720 FE_OFN773_n3720 FE_OFN772_n3720 CLKBUFX2TS
XFE_OFC772_n3720 FE_OFN772_n3720 FE_OFN771_n3720 CLKBUFX2TS
XFE_OFC771_n3720 FE_OFN771_n3720 FE_OFN769_n3720 CLKBUFX2TS
XFE_OFC770_n3720 FE_OFN770_n3720 FE_OFN769_n3720 CLKBUFX2TS
XFE_OFC769_n3720 FE_OFN769_n3720 FE_OFN768_n3720 CLKBUFX2TS
XFE_OFC768_n3720 FE_OFN768_n3720 FE_OFN766_n3720 CLKBUFX2TS
XFE_OFC767_n3720 FE_OFN767_n3720 FE_OFN765_n3720 CLKBUFX2TS
XFE_OFC766_n3720 FE_OFN766_n3720 FE_OFN765_n3720 CLKBUFX2TS
XFE_OFC765_n3720 FE_OFN765_n3720 n3720 CLKBUFX2TS
XFE_OFC764_n3721 FE_OFN764_n3721 FE_OFN763_n3721 CLKBUFX2TS
XFE_OFC763_n3721 FE_OFN763_n3721 FE_OFN761_n3721 CLKBUFX2TS
XFE_OFC762_n3721 FE_OFN762_n3721 FE_OFN761_n3721 CLKBUFX2TS
XFE_OFC761_n3721 FE_OFN761_n3721 FE_OFN760_n3721 CLKBUFX2TS
XFE_OFC760_n3721 FE_OFN760_n3721 FE_OFN758_n3721 CLKBUFX2TS
XFE_OFC759_n3721 FE_OFN759_n3721 FE_OFN758_n3721 CLKBUFX2TS
XFE_OFC758_n3721 FE_OFN758_n3721 FE_OFN757_n3721 CLKBUFX2TS
XFE_OFC757_n3721 FE_OFN757_n3721 FE_OFN756_n3721 CLKBUFX2TS
XFE_OFC756_n3721 FE_OFN756_n3721 n3721 CLKBUFX2TS
XFE_OFC755_n3721 FE_OFN755_n3721 n3721 CLKBUFX2TS
XFE_OFC754_n3722 FE_OFN754_n3722 FE_OFN753_n3722 CLKBUFX2TS
XFE_OFC753_n3722 FE_OFN753_n3722 FE_OFN751_n3722 CLKBUFX2TS
XFE_OFC752_n3722 FE_OFN752_n3722 FE_OFN751_n3722 CLKBUFX2TS
XFE_OFC751_n3722 FE_OFN751_n3722 FE_OFN750_n3722 CLKBUFX2TS
XFE_OFC750_n3722 FE_OFN750_n3722 FE_OFN748_n3722 CLKBUFX2TS
XFE_OFC749_n3722 FE_OFN749_n3722 FE_OFN748_n3722 CLKBUFX2TS
XFE_OFC748_n3722 FE_OFN748_n3722 FE_OFN747_n3722 CLKBUFX2TS
XFE_OFC747_n3722 FE_OFN747_n3722 FE_OFN745_n3722 CLKBUFX2TS
XFE_OFC746_n3722 FE_OFN746_n3722 n3722 CLKBUFX2TS
XFE_OFC745_n3722 FE_OFN745_n3722 n3722 CLKBUFX2TS
XFE_OFC744_n4829 FE_OFN744_n4829 FE_OFN743_n4829 CLKBUFX2TS
XFE_OFC743_n4829 FE_OFN743_n4829 FE_OFN740_n4829 CLKBUFX2TS
XFE_OFC742_n4829 FE_OFN742_n4829 FE_OFN741_n4829 CLKBUFX2TS
XFE_OFC741_n4829 FE_OFN741_n4829 FE_OFN739_n4829 CLKBUFX2TS
XFE_OFC740_n4829 FE_OFN740_n4829 FE_OFN738_n4829 CLKBUFX2TS
XFE_OFC739_n4829 FE_OFN739_n4829 FE_OFN737_n4829 CLKBUFX2TS
XFE_OFC738_n4829 FE_OFN738_n4829 FE_OFN737_n4829 CLKBUFX2TS
XFE_OFC737_n4829 FE_OFN737_n4829 FE_OFN736_n4829 CLKBUFX2TS
XFE_OFC736_n4829 FE_OFN736_n4829 n4829 CLKBUFX2TS
XFE_OFC735_n4829 FE_OFN735_n4829 n4829 CLKBUFX2TS
XFE_OFC734_n8057 FE_OFN734_n8057 FE_OFN733_n8057 CLKBUFX2TS
XFE_OFC733_n8057 FE_OFN733_n8057 FE_OFN732_n8057 CLKBUFX2TS
XFE_OFC732_n8057 FE_OFN732_n8057 n8057 CLKBUFX2TS
XFE_OFC731_n8058 FE_OFN731_n8058 FE_OFN730_n8058 CLKBUFX2TS
XFE_OFC730_n8058 FE_OFN730_n8058 FE_OFN729_n8058 CLKBUFX2TS
XFE_OFC729_n8058 FE_OFN729_n8058 n8058 CLKBUFX2TS
XFE_OFC728_n4643 FE_OFN728_n4643 FE_OFN727_n4643 CLKBUFX2TS
XFE_OFC727_n4643 FE_OFN727_n4643 FE_OFN725_n4643 CLKBUFX2TS
XFE_OFC726_n4643 FE_OFN726_n4643 FE_OFN725_n4643 CLKBUFX2TS
XFE_OFC725_n4643 FE_OFN725_n4643 FE_OFN724_n4643 CLKBUFX2TS
XFE_OFC724_n4643 FE_OFN724_n4643 FE_OFN723_n4643 CLKBUFX2TS
XFE_OFC723_n4643 FE_OFN723_n4643 FE_OFN722_n4643 CLKBUFX2TS
XFE_OFC722_n4643 FE_OFN722_n4643 FE_OFN720_n4643 CLKBUFX2TS
XFE_OFC721_n4643 FE_OFN721_n4643 FE_OFN1823_n4643 CLKBUFX2TS
XFE_OFC720_n4643 FE_OFN720_n4643 FE_OFN1823_n4643 CLKBUFX2TS
XFE_OFC719_n4643 FE_OFN719_n4643 n4643 CLKBUFX2TS
XFE_OFC718_n8051 FE_OFN718_n8051 FE_OFN717_n8051 CLKBUFX2TS
XFE_OFC717_n8051 FE_OFN717_n8051 n8051 CLKBUFX2TS
XFE_OFC716_n4207 FE_OFN716_n4207 FE_OFN714_n4207 CLKBUFX2TS
XFE_OFC715_n4207 FE_OFN715_n4207 FE_OFN712_n4207 CLKBUFX2TS
XFE_OFC714_n4207 FE_OFN714_n4207 FE_OFN712_n4207 CLKBUFX2TS
XFE_OFC713_n4207 FE_OFN713_n4207 FE_OFN710_n4207 CLKBUFX2TS
XFE_OFC712_n4207 FE_OFN712_n4207 FE_OFN710_n4207 CLKBUFX2TS
XFE_OFC711_n4207 FE_OFN711_n4207 FE_OFN709_n4207 CLKBUFX2TS
XFE_OFC710_n4207 FE_OFN710_n4207 FE_OFN709_n4207 CLKBUFX2TS
XFE_OFC709_n4207 FE_OFN709_n4207 n4207 CLKBUFX2TS
XFE_OFC708_n3959 FE_OFN708_n3959 FE_OFN705_n3959 CLKBUFX2TS
XFE_OFC707_n3959 FE_OFN707_n3959 FE_OFN703_n3959 CLKBUFX2TS
XFE_OFC706_n3959 FE_OFN706_n3959 FE_OFN703_n3959 CLKBUFX2TS
XFE_OFC705_n3959 FE_OFN705_n3959 FE_OFN702_n3959 CLKBUFX2TS
XFE_OFC704_n3959 FE_OFN704_n3959 FE_OFN701_n3959 CLKBUFX2TS
XFE_OFC703_n3959 FE_OFN703_n3959 FE_OFN702_n3959 CLKBUFX2TS
XFE_OFC702_n3959 FE_OFN702_n3959 FE_OFN699_n3959 CLKBUFX2TS
XFE_OFC701_n3959 FE_OFN701_n3959 FE_OFN699_n3959 CLKBUFX2TS
XFE_OFC700_n3959 FE_OFN700_n3959 n3959 CLKBUFX2TS
XFE_OFC699_n3959 FE_OFN699_n3959 n3959 CLKBUFX2TS
XFE_OFC698_n8052 FE_OFN698_n8052 FE_OFN696_n8052 CLKBUFX2TS
XFE_OFC697_n8052 FE_OFN697_n8052 FE_OFN696_n8052 CLKBUFX2TS
XFE_OFC696_n8052 FE_OFN696_n8052 n8052 CLKBUFX2TS
XFE_OFC695_n4134 FE_OFN695_n4134 FE_OFN694_n4134 CLKBUFX2TS
XFE_OFC694_n4134 FE_OFN694_n4134 FE_OFN693_n4134 CLKBUFX2TS
XFE_OFC693_n4134 FE_OFN693_n4134 FE_OFN690_n4134 CLKINVX1TS
XFE_OFC692_n4134 FE_OFN692_n4134 FE_OFN690_n4134 CLKINVX1TS
XFE_OFC691_n4134 FE_OFN691_n4134 FE_OFN690_n4134 CLKINVX1TS
XFE_OFC690_n4134 FE_OFN690_n4134 FE_OFN689_n4134 CLKINVX1TS
XFE_OFC689_n4134 FE_OFN689_n4134 FE_OFN688_n4134 CLKBUFX2TS
XFE_OFC688_n4134 FE_OFN688_n4134 FE_OFN687_n4134 CLKBUFX2TS
XFE_OFC687_n4134 FE_OFN687_n4134 FE_OFN685_n4134 CLKBUFX2TS
XFE_OFC686_n4134 FE_OFN686_n4134 FE_OFN685_n4134 CLKBUFX2TS
XFE_OFC685_n4134 FE_OFN685_n4134 FE_OFN684_n4134 CLKBUFX2TS
XFE_OFC684_n4134 FE_OFN684_n4134 FE_OFN683_n4134 CLKBUFX2TS
XFE_OFC683_n4134 FE_OFN683_n4134 n4134 CLKBUFX2TS
XFE_OFC682_n8050 FE_OFN682_n8050 FE_OFN681_n8050 CLKBUFX2TS
XFE_OFC681_n8050 FE_OFN681_n8050 FE_OFN680_n8050 CLKBUFX2TS
XFE_OFC680_n8050 FE_OFN680_n8050 n8050 CLKBUFX2TS
XFE_OFC679_n8050 FE_OFN679_n8050 n8050 CLKBUFX2TS
XFE_OFC678_n7295 FE_OFN678_n7295 n7295 CLKBUFX2TS
XFE_OFC677_n4759 FE_OFN677_n4759 FE_OFN676_n4759 CLKBUFX2TS
XFE_OFC676_n4759 FE_OFN676_n4759 FE_OFN674_n4759 CLKBUFX2TS
XFE_OFC675_n4759 FE_OFN675_n4759 FE_OFN674_n4759 CLKBUFX2TS
XFE_OFC674_n4759 FE_OFN674_n4759 FE_OFN673_n4759 CLKBUFX2TS
XFE_OFC673_n4759 FE_OFN673_n4759 FE_OFN672_n4759 CLKBUFX2TS
XFE_OFC672_n4759 FE_OFN672_n4759 FE_OFN671_n4759 CLKBUFX2TS
XFE_OFC671_n4759 FE_OFN671_n4759 FE_OFN670_n4759 CLKBUFX2TS
XFE_OFC670_n4759 FE_OFN670_n4759 FE_OFN668_n4759 CLKBUFX2TS
XFE_OFC669_n4759 FE_OFN669_n4759 FE_OFN667_n4759 CLKBUFX2TS
XFE_OFC668_n4759 FE_OFN668_n4759 FE_OFN667_n4759 CLKBUFX2TS
XFE_OFC667_n4759 FE_OFN667_n4759 FE_OFN666_n4759 CLKBUFX2TS
XFE_OFC666_n4759 FE_OFN666_n4759 n4759 CLKBUFX2TS
XFE_OFC665_n8053 FE_OFN665_n8053 FE_OFN664_n8053 CLKBUFX2TS
XFE_OFC664_n8053 FE_OFN664_n8053 n8053 CLKBUFX2TS
XFE_OFC663_n4747 FE_OFN663_n4747 FE_OFN662_n4747 CLKBUFX2TS
XFE_OFC662_n4747 FE_OFN662_n4747 FE_OFN661_n4747 CLKBUFX2TS
XFE_OFC661_n4747 FE_OFN661_n4747 FE_OFN660_n4747 CLKBUFX2TS
XFE_OFC660_n4747 FE_OFN660_n4747 FE_OFN659_n4747 CLKBUFX2TS
XFE_OFC659_n4747 FE_OFN659_n4747 FE_OFN658_n4747 CLKBUFX2TS
XFE_OFC658_n4747 FE_OFN658_n4747 FE_OFN656_n4747 CLKBUFX2TS
XFE_OFC657_n4747 FE_OFN657_n4747 FE_OFN655_n4747 CLKBUFX2TS
XFE_OFC656_n4747 FE_OFN656_n4747 FE_OFN654_n4747 CLKBUFX2TS
XFE_OFC655_n4747 FE_OFN655_n4747 FE_OFN652_n4747 CLKBUFX2TS
XFE_OFC654_n4747 FE_OFN654_n4747 FE_OFN653_n4747 CLKBUFX2TS
XFE_OFC653_n4747 FE_OFN653_n4747 n4747 CLKBUFX2TS
XFE_OFC652_n4747 FE_OFN652_n4747 n4747 CLKBUFX2TS
XFE_OFC651_n4741 FE_OFN651_n4741 FE_OFN650_n4741 CLKBUFX2TS
XFE_OFC650_n4741 FE_OFN650_n4741 FE_OFN649_n4741 CLKBUFX2TS
XFE_OFC649_n4741 FE_OFN649_n4741 FE_OFN648_n4741 CLKBUFX2TS
XFE_OFC648_n4741 FE_OFN648_n4741 FE_OFN647_n4741 CLKBUFX2TS
XFE_OFC647_n4741 FE_OFN647_n4741 FE_OFN646_n4741 CLKBUFX2TS
XFE_OFC646_n4741 FE_OFN646_n4741 FE_OFN644_n4741 CLKBUFX2TS
XFE_OFC645_n4741 FE_OFN645_n4741 FE_OFN643_n4741 CLKBUFX2TS
XFE_OFC644_n4741 FE_OFN644_n4741 FE_OFN640_n4741 CLKBUFX2TS
XFE_OFC643_n4741 FE_OFN643_n4741 FE_OFN641_n4741 CLKBUFX2TS
XFE_OFC642_n4741 FE_OFN642_n4741 FE_OFN640_n4741 CLKBUFX2TS
XFE_OFC641_n4741 FE_OFN641_n4741 n4741 CLKBUFX2TS
XFE_OFC640_n4741 FE_OFN640_n4741 n4741 CLKBUFX2TS
XFE_OFC639_n4742 FE_OFN639_n4742 FE_OFN636_n4742 CLKBUFX2TS
XFE_OFC638_n4742 FE_OFN638_n4742 FE_OFN635_n4742 CLKBUFX2TS
XFE_OFC637_n4742 FE_OFN637_n4742 FE_OFN635_n4742 CLKBUFX2TS
XFE_OFC636_n4742 FE_OFN636_n4742 FE_OFN633_n4742 CLKBUFX2TS
XFE_OFC635_n4742 FE_OFN635_n4742 FE_OFN632_n4742 CLKBUFX2TS
XFE_OFC634_n4742 FE_OFN634_n4742 FE_OFN633_n4742 CLKBUFX2TS
XFE_OFC633_n4742 FE_OFN633_n4742 FE_OFN630_n4742 CLKBUFX2TS
XFE_OFC632_n4742 FE_OFN632_n4742 FE_OFN631_n4742 CLKBUFX2TS
XFE_OFC631_n4742 FE_OFN631_n4742 n4742 CLKBUFX2TS
XFE_OFC630_n4742 FE_OFN630_n4742 n4742 CLKBUFX2TS
XFE_OFC629_n4735 FE_OFN629_n4735 FE_OFN628_n4735 CLKBUFX2TS
XFE_OFC628_n4735 FE_OFN628_n4735 FE_OFN627_n4735 CLKBUFX2TS
XFE_OFC627_n4735 FE_OFN627_n4735 FE_OFN625_n4735 CLKBUFX2TS
XFE_OFC626_n4735 FE_OFN626_n4735 FE_OFN624_n4735 CLKBUFX2TS
XFE_OFC625_n4735 FE_OFN625_n4735 FE_OFN622_n4735 CLKBUFX2TS
XFE_OFC624_n4735 FE_OFN624_n4735 FE_OFN623_n4735 CLKBUFX2TS
XFE_OFC623_n4735 FE_OFN623_n4735 FE_OFN620_n4735 CLKBUFX2TS
XFE_OFC622_n4735 FE_OFN622_n4735 FE_OFN621_n4735 CLKBUFX2TS
XFE_OFC621_n4735 FE_OFN621_n4735 FE_OFN619_n4735 CLKBUFX2TS
XFE_OFC620_n4735 FE_OFN620_n4735 FE_OFN619_n4735 CLKBUFX2TS
XFE_OFC619_n4735 FE_OFN619_n4735 n4735 CLKBUFX2TS
XFE_OFC618_n4735 FE_OFN618_n4735 n4735 CLKBUFX2TS
XFE_OFC617_n4729 FE_OFN617_n4729 FE_OFN616_n4729 CLKBUFX2TS
XFE_OFC616_n4729 FE_OFN616_n4729 FE_OFN615_n4729 CLKBUFX2TS
XFE_OFC615_n4729 FE_OFN615_n4729 FE_OFN614_n4729 CLKBUFX2TS
XFE_OFC614_n4729 FE_OFN614_n4729 FE_OFN610_n4729 CLKBUFX2TS
XFE_OFC613_n4729 FE_OFN613_n4729 FE_OFN611_n4729 CLKBUFX2TS
XFE_OFC612_n4729 FE_OFN612_n4729 FE_OFN611_n4729 CLKBUFX2TS
XFE_OFC611_n4729 FE_OFN611_n4729 FE_OFN607_n4729 CLKBUFX2TS
XFE_OFC610_n4729 FE_OFN610_n4729 FE_OFN608_n4729 CLKBUFX2TS
XFE_OFC609_n4729 FE_OFN609_n4729 FE_OFN607_n4729 CLKBUFX2TS
XFE_OFC608_n4729 FE_OFN608_n4729 FE_OFN606_n4729 CLKBUFX2TS
XFE_OFC607_n4729 FE_OFN607_n4729 FE_OFN606_n4729 CLKBUFX2TS
XFE_OFC606_n4729 FE_OFN606_n4729 n4729 CLKBUFX2TS
XFE_OFC605_n4723 FE_OFN605_n4723 FE_OFN603_n4723 CLKBUFX2TS
XFE_OFC604_n4723 FE_OFN604_n4723 FE_OFN603_n4723 CLKBUFX2TS
XFE_OFC603_n4723 FE_OFN603_n4723 FE_OFN601_n4723 CLKBUFX2TS
XFE_OFC602_n4723 FE_OFN602_n4723 FE_OFN600_n4723 CLKBUFX2TS
XFE_OFC601_n4723 FE_OFN601_n4723 FE_OFN598_n4723 CLKBUFX2TS
XFE_OFC600_n4723 FE_OFN600_n4723 FE_OFN597_n4723 CLKBUFX2TS
XFE_OFC599_n4723 FE_OFN599_n4723 FE_OFN597_n4723 CLKBUFX2TS
XFE_OFC598_n4723 FE_OFN598_n4723 FE_OFN595_n4723 CLKBUFX2TS
XFE_OFC597_n4723 FE_OFN597_n4723 FE_OFN596_n4723 CLKBUFX2TS
XFE_OFC596_n4723 FE_OFN596_n4723 FE_OFN594_n4723 CLKBUFX2TS
XFE_OFC595_n4723 FE_OFN595_n4723 FE_OFN594_n4723 CLKBUFX2TS
XFE_OFC594_n4723 FE_OFN594_n4723 n4723 CLKBUFX2TS
XFE_OFC593_n4723 FE_OFN593_n4723 n4723 CLKBUFX2TS
XFE_OFC592_n4724 FE_OFN592_n4724 FE_OFN591_n4724 CLKBUFX2TS
XFE_OFC591_n4724 FE_OFN591_n4724 FE_OFN589_n4724 CLKBUFX2TS
XFE_OFC590_n4724 FE_OFN590_n4724 FE_OFN586_n4724 CLKBUFX2TS
XFE_OFC589_n4724 FE_OFN589_n4724 FE_OFN587_n4724 CLKBUFX2TS
XFE_OFC588_n4724 FE_OFN588_n4724 FE_OFN586_n4724 CLKBUFX2TS
XFE_OFC587_n4724 FE_OFN587_n4724 FE_OFN585_n4724 CLKBUFX2TS
XFE_OFC586_n4724 FE_OFN586_n4724 FE_OFN584_n4724 CLKBUFX2TS
XFE_OFC585_n4724 FE_OFN585_n4724 FE_OFN582_n4724 CLKBUFX2TS
XFE_OFC584_n4724 FE_OFN584_n4724 FE_OFN583_n4724 CLKBUFX2TS
XFE_OFC583_n4724 FE_OFN583_n4724 n4724 CLKBUFX2TS
XFE_OFC582_n4724 FE_OFN582_n4724 n4724 CLKBUFX2TS
XFE_OFC581_n4717 FE_OFN581_n4717 FE_OFN578_n4717 CLKBUFX2TS
XFE_OFC580_n4717 FE_OFN580_n4717 FE_OFN578_n4717 CLKBUFX2TS
XFE_OFC579_n4717 FE_OFN579_n4717 FE_OFN576_n4717 CLKBUFX2TS
XFE_OFC578_n4717 FE_OFN578_n4717 FE_OFN575_n4717 CLKBUFX2TS
XFE_OFC577_n4717 FE_OFN577_n4717 FE_OFN573_n4717 CLKBUFX2TS
XFE_OFC576_n4717 FE_OFN576_n4717 FE_OFN574_n4717 CLKBUFX2TS
XFE_OFC575_n4717 FE_OFN575_n4717 FE_OFN572_n4717 CLKBUFX2TS
XFE_OFC574_n4717 FE_OFN574_n4717 FE_OFN572_n4717 CLKBUFX2TS
XFE_OFC573_n4717 FE_OFN573_n4717 FE_OFN571_n4717 CLKBUFX2TS
XFE_OFC572_n4717 FE_OFN572_n4717 FE_OFN570_n4717 CLKBUFX2TS
XFE_OFC571_n4717 FE_OFN571_n4717 FE_OFN570_n4717 CLKBUFX2TS
XFE_OFC570_n4717 FE_OFN570_n4717 n4717 CLKBUFX2TS
XFE_OFC569_n4711 FE_OFN569_n4711 FE_OFN566_n4711 CLKBUFX2TS
XFE_OFC568_n4711 FE_OFN568_n4711 FE_OFN564_n4711 CLKBUFX2TS
XFE_OFC567_n4711 FE_OFN567_n4711 FE_OFN564_n4711 CLKBUFX2TS
XFE_OFC566_n4711 FE_OFN566_n4711 FE_OFN565_n4711 CLKBUFX2TS
XFE_OFC565_n4711 FE_OFN565_n4711 FE_OFN563_n4711 CLKBUFX2TS
XFE_OFC564_n4711 FE_OFN564_n4711 FE_OFN561_n4711 CLKBUFX2TS
XFE_OFC563_n4711 FE_OFN563_n4711 FE_OFN562_n4711 CLKBUFX2TS
XFE_OFC562_n4711 FE_OFN562_n4711 FE_OFN559_n4711 CLKBUFX2TS
XFE_OFC561_n4711 FE_OFN561_n4711 FE_OFN559_n4711 CLKBUFX2TS
XFE_OFC560_n4711 FE_OFN560_n4711 FE_OFN559_n4711 CLKBUFX2TS
XFE_OFC559_n4711 FE_OFN559_n4711 FE_OFN558_n4711 CLKBUFX2TS
XFE_OFC558_n4711 FE_OFN558_n4711 n4711 CLKBUFX2TS
XFE_OFC557_n4705 FE_OFN557_n4705 FE_OFN552_n4705 CLKBUFX2TS
XFE_OFC556_n4705 FE_OFN556_n4705 FE_OFN551_n4705 CLKBUFX2TS
XFE_OFC555_n4705 FE_OFN555_n4705 FE_OFN552_n4705 CLKBUFX2TS
XFE_OFC554_n4705 FE_OFN554_n4705 FE_OFN550_n4705 CLKBUFX2TS
XFE_OFC553_n4705 FE_OFN553_n4705 FE_OFN548_n4705 CLKBUFX2TS
XFE_OFC552_n4705 FE_OFN552_n4705 FE_OFN548_n4705 CLKBUFX2TS
XFE_OFC551_n4705 FE_OFN551_n4705 FE_OFN549_n4705 CLKBUFX2TS
XFE_OFC550_n4705 FE_OFN550_n4705 FE_OFN549_n4705 CLKBUFX2TS
XFE_OFC549_n4705 FE_OFN549_n4705 FE_OFN547_n4705 CLKBUFX2TS
XFE_OFC548_n4705 FE_OFN548_n4705 FE_OFN547_n4705 CLKBUFX2TS
XFE_OFC547_n4705 FE_OFN547_n4705 n4705 CLKBUFX2TS
XFE_OFC546_n4705 FE_OFN546_n4705 n4705 CLKBUFX2TS
XFE_OFC545_n4699 FE_OFN545_n4699 FE_OFN541_n4699 CLKBUFX2TS
XFE_OFC544_n4699 FE_OFN544_n4699 FE_OFN542_n4699 CLKBUFX2TS
XFE_OFC543_n4699 FE_OFN543_n4699 FE_OFN541_n4699 CLKBUFX2TS
XFE_OFC542_n4699 FE_OFN542_n4699 FE_OFN539_n4699 CLKBUFX2TS
XFE_OFC541_n4699 FE_OFN541_n4699 FE_OFN540_n4699 CLKBUFX2TS
XFE_OFC540_n4699 FE_OFN540_n4699 FE_OFN537_n4699 CLKBUFX2TS
XFE_OFC539_n4699 FE_OFN539_n4699 FE_OFN536_n4699 CLKBUFX2TS
XFE_OFC538_n4699 FE_OFN538_n4699 FE_OFN536_n4699 CLKBUFX2TS
XFE_OFC537_n4699 FE_OFN537_n4699 FE_OFN535_n4699 CLKBUFX2TS
XFE_OFC536_n4699 FE_OFN536_n4699 FE_OFN535_n4699 CLKBUFX2TS
XFE_OFC535_n4699 FE_OFN535_n4699 n4699 CLKBUFX2TS
XFE_OFC534_n4699 FE_OFN534_n4699 n4699 CLKBUFX2TS
XFE_OFC533_n4700 FE_OFN533_n4700 FE_OFN531_n4700 CLKBUFX2TS
XFE_OFC532_n4700 FE_OFN532_n4700 FE_OFN530_n4700 CLKBUFX2TS
XFE_OFC531_n4700 FE_OFN531_n4700 FE_OFN529_n4700 CLKBUFX2TS
XFE_OFC530_n4700 FE_OFN530_n4700 FE_OFN528_n4700 CLKBUFX2TS
XFE_OFC529_n4700 FE_OFN529_n4700 FE_OFN526_n4700 CLKBUFX2TS
XFE_OFC528_n4700 FE_OFN528_n4700 FE_OFN527_n4700 CLKBUFX2TS
XFE_OFC527_n4700 FE_OFN527_n4700 FE_OFN525_n4700 CLKBUFX2TS
XFE_OFC526_n4700 FE_OFN526_n4700 FE_OFN524_n4700 CLKBUFX2TS
XFE_OFC525_n4700 FE_OFN525_n4700 FE_OFN523_n4700 CLKBUFX2TS
XFE_OFC524_n4700 FE_OFN524_n4700 FE_OFN523_n4700 CLKBUFX2TS
XFE_OFC523_n4700 FE_OFN523_n4700 n4700 CLKBUFX2TS
XFE_OFC522_n4693 FE_OFN522_n4693 FE_OFN521_n4693 CLKBUFX2TS
XFE_OFC521_n4693 FE_OFN521_n4693 FE_OFN520_n4693 CLKBUFX2TS
XFE_OFC520_n4693 FE_OFN520_n4693 FE_OFN519_n4693 CLKBUFX2TS
XFE_OFC519_n4693 FE_OFN519_n4693 FE_OFN518_n4693 CLKBUFX2TS
XFE_OFC518_n4693 FE_OFN518_n4693 FE_OFN517_n4693 CLKBUFX2TS
XFE_OFC517_n4693 FE_OFN517_n4693 FE_OFN516_n4693 CLKBUFX2TS
XFE_OFC516_n4693 FE_OFN516_n4693 FE_OFN515_n4693 CLKBUFX2TS
XFE_OFC515_n4693 FE_OFN515_n4693 FE_OFN513_n4693 CLKBUFX2TS
XFE_OFC514_n4693 FE_OFN514_n4693 FE_OFN513_n4693 CLKBUFX2TS
XFE_OFC513_n4693 FE_OFN513_n4693 FE_OFN512_n4693 CLKBUFX2TS
XFE_OFC512_n4693 FE_OFN512_n4693 FE_OFN511_n4693 CLKBUFX2TS
XFE_OFC511_n4693 FE_OFN511_n4693 n4693 CLKBUFX2TS
XFE_OFC510_n8055 FE_OFN510_n8055 FE_OFN509_n8055 CLKBUFX2TS
XFE_OFC509_n8055 FE_OFN509_n8055 FE_OFN508_n8055 CLKBUFX2TS
XFE_OFC508_n8055 FE_OFN508_n8055 n8055 CLKBUFX2TS
XFE_OFC507_n4681 FE_OFN507_n4681 FE_OFN505_n4681 CLKBUFX2TS
XFE_OFC506_n4681 FE_OFN506_n4681 FE_OFN504_n4681 CLKBUFX2TS
XFE_OFC505_n4681 FE_OFN505_n4681 FE_OFN503_n4681 CLKBUFX2TS
XFE_OFC504_n4681 FE_OFN504_n4681 FE_OFN503_n4681 CLKBUFX2TS
XFE_OFC503_n4681 FE_OFN503_n4681 FE_OFN502_n4681 CLKBUFX2TS
XFE_OFC502_n4681 FE_OFN502_n4681 FE_OFN501_n4681 CLKBUFX2TS
XFE_OFC501_n4681 FE_OFN501_n4681 FE_OFN500_n4681 CLKBUFX2TS
XFE_OFC500_n4681 FE_OFN500_n4681 FE_OFN499_n4681 CLKBUFX2TS
XFE_OFC499_n4681 FE_OFN499_n4681 FE_OFN498_n4681 CLKBUFX2TS
XFE_OFC498_n4681 FE_OFN498_n4681 FE_OFN497_n4681 CLKBUFX2TS
XFE_OFC497_n4681 FE_OFN497_n4681 n4681 CLKBUFX2TS
XFE_OFC496_n4681 FE_OFN496_n4681 n4681 CLKBUFX2TS
XFE_OFC495_n4682 FE_OFN495_n4682 FE_OFN491_n4682 CLKBUFX2TS
XFE_OFC494_n4682 FE_OFN494_n4682 FE_OFN492_n4682 CLKBUFX2TS
XFE_OFC493_n4682 FE_OFN493_n4682 FE_OFN492_n4682 CLKBUFX2TS
XFE_OFC492_n4682 FE_OFN492_n4682 FE_OFN490_n4682 CLKBUFX2TS
XFE_OFC491_n4682 FE_OFN491_n4682 FE_OFN487_n4682 CLKBUFX2TS
XFE_OFC490_n4682 FE_OFN490_n4682 FE_OFN488_n4682 CLKBUFX2TS
XFE_OFC489_n4682 FE_OFN489_n4682 FE_OFN486_n4682 CLKBUFX2TS
XFE_OFC488_n4682 FE_OFN488_n4682 n4682 CLKBUFX2TS
XFE_OFC487_n4682 FE_OFN487_n4682 FE_OFN486_n4682 CLKBUFX2TS
XFE_OFC486_n4682 FE_OFN486_n4682 n4682 CLKBUFX2TS
XFE_OFC485_n4675 FE_OFN485_n4675 FE_OFN483_n4675 CLKBUFX2TS
XFE_OFC484_n4675 FE_OFN484_n4675 FE_OFN483_n4675 CLKBUFX2TS
XFE_OFC483_n4675 FE_OFN483_n4675 FE_OFN482_n4675 CLKBUFX2TS
XFE_OFC482_n4675 FE_OFN482_n4675 FE_OFN481_n4675 CLKBUFX2TS
XFE_OFC481_n4675 FE_OFN481_n4675 FE_OFN479_n4675 CLKBUFX2TS
XFE_OFC480_n4675 FE_OFN480_n4675 FE_OFN479_n4675 CLKBUFX2TS
XFE_OFC479_n4675 FE_OFN479_n4675 FE_OFN478_n4675 CLKBUFX2TS
XFE_OFC478_n4675 FE_OFN478_n4675 FE_OFN477_n4675 CLKBUFX2TS
XFE_OFC477_n4675 FE_OFN477_n4675 FE_OFN476_n4675 CLKBUFX2TS
XFE_OFC476_n4675 FE_OFN476_n4675 FE_OFN475_n4675 CLKBUFX2TS
XFE_OFC475_n4675 FE_OFN475_n4675 FE_OFN474_n4675 CLKBUFX2TS
XFE_OFC474_n4675 FE_OFN474_n4675 n4675 CLKBUFX2TS
XFE_OFC473_n4676 FE_OFN473_n4676 FE_OFN471_n4676 CLKBUFX2TS
XFE_OFC472_n4676 FE_OFN472_n4676 FE_OFN471_n4676 CLKBUFX2TS
XFE_OFC471_n4676 FE_OFN471_n4676 FE_OFN468_n4676 CLKBUFX2TS
XFE_OFC470_n4676 FE_OFN470_n4676 FE_OFN467_n4676 CLKBUFX2TS
XFE_OFC469_n4676 FE_OFN469_n4676 FE_OFN467_n4676 CLKBUFX2TS
XFE_OFC468_n4676 FE_OFN468_n4676 FE_OFN466_n4676 CLKBUFX2TS
XFE_OFC467_n4676 FE_OFN467_n4676 FE_OFN465_n4676 CLKBUFX2TS
XFE_OFC466_n4676 FE_OFN466_n4676 FE_OFN464_n4676 CLKBUFX2TS
XFE_OFC465_n4676 FE_OFN465_n4676 FE_OFN463_n4676 CLKBUFX2TS
XFE_OFC464_n4676 FE_OFN464_n4676 FE_OFN463_n4676 CLKBUFX2TS
XFE_OFC463_n4676 FE_OFN463_n4676 n4676 CLKBUFX2TS
XFE_OFC462_n4688 FE_OFN462_n4688 FE_OFN460_n4688 CLKBUFX2TS
XFE_OFC461_n4688 FE_OFN461_n4688 FE_OFN459_n4688 CLKBUFX2TS
XFE_OFC460_n4688 FE_OFN460_n4688 FE_OFN459_n4688 CLKBUFX2TS
XFE_OFC459_n4688 FE_OFN459_n4688 FE_OFN458_n4688 CLKBUFX2TS
XFE_OFC458_n4688 FE_OFN458_n4688 FE_OFN457_n4688 CLKBUFX2TS
XFE_OFC457_n4688 FE_OFN457_n4688 FE_OFN456_n4688 CLKBUFX2TS
XFE_OFC456_n4688 FE_OFN456_n4688 FE_OFN454_n4688 CLKBUFX2TS
XFE_OFC455_n4688 FE_OFN455_n4688 FE_OFN453_n4688 CLKBUFX2TS
XFE_OFC454_n4688 FE_OFN454_n4688 n4688 CLKBUFX2TS
XFE_OFC453_n4688 FE_OFN453_n4688 n4688 CLKBUFX2TS
XFE_OFC452_n4694 FE_OFN452_n4694 FE_OFN450_n4694 CLKBUFX2TS
XFE_OFC451_n4694 FE_OFN451_n4694 FE_OFN450_n4694 CLKBUFX2TS
XFE_OFC450_n4694 FE_OFN450_n4694 FE_OFN448_n4694 CLKBUFX2TS
XFE_OFC449_n4694 FE_OFN449_n4694 FE_OFN447_n4694 CLKBUFX2TS
XFE_OFC448_n4694 FE_OFN448_n4694 FE_OFN445_n4694 CLKBUFX2TS
XFE_OFC447_n4694 FE_OFN447_n4694 FE_OFN446_n4694 CLKBUFX2TS
XFE_OFC446_n4694 FE_OFN446_n4694 FE_OFN444_n4694 CLKBUFX2TS
XFE_OFC445_n4694 FE_OFN445_n4694 FE_OFN443_n4694 CLKBUFX2TS
XFE_OFC444_n4694 FE_OFN444_n4694 n4694 CLKBUFX2TS
XFE_OFC443_n4694 FE_OFN443_n4694 n4694 CLKBUFX2TS
XFE_OFC442_n4706 FE_OFN442_n4706 FE_OFN438_n4706 CLKBUFX2TS
XFE_OFC441_n4706 FE_OFN441_n4706 FE_OFN438_n4706 CLKBUFX2TS
XFE_OFC440_n4706 FE_OFN440_n4706 FE_OFN435_n4706 CLKBUFX2TS
XFE_OFC439_n4706 FE_OFN439_n4706 FE_OFN436_n4706 CLKBUFX2TS
XFE_OFC438_n4706 FE_OFN438_n4706 FE_OFN434_n4706 CLKBUFX2TS
XFE_OFC437_n4706 FE_OFN437_n4706 FE_OFN434_n4706 CLKBUFX2TS
XFE_OFC436_n4706 FE_OFN436_n4706 FE_OFN433_n4706 CLKBUFX2TS
XFE_OFC435_n4706 FE_OFN435_n4706 FE_OFN433_n4706 CLKBUFX2TS
XFE_OFC434_n4706 FE_OFN434_n4706 n4706 CLKBUFX2TS
XFE_OFC433_n4706 FE_OFN433_n4706 n4706 CLKBUFX2TS
XFE_OFC432_n4712 FE_OFN432_n4712 FE_OFN429_n4712 CLKBUFX2TS
XFE_OFC431_n4712 FE_OFN431_n4712 FE_OFN427_n4712 CLKBUFX2TS
XFE_OFC430_n4712 FE_OFN430_n4712 FE_OFN427_n4712 CLKBUFX2TS
XFE_OFC429_n4712 FE_OFN429_n4712 FE_OFN428_n4712 CLKBUFX2TS
XFE_OFC428_n4712 FE_OFN428_n4712 FE_OFN426_n4712 CLKBUFX2TS
XFE_OFC427_n4712 FE_OFN427_n4712 FE_OFN425_n4712 CLKBUFX2TS
XFE_OFC426_n4712 FE_OFN426_n4712 FE_OFN424_n4712 CLKBUFX2TS
XFE_OFC425_n4712 FE_OFN425_n4712 FE_OFN424_n4712 CLKBUFX2TS
XFE_OFC424_n4712 FE_OFN424_n4712 FE_OFN423_n4712 CLKBUFX2TS
XFE_OFC423_n4712 FE_OFN423_n4712 n4712 CLKBUFX2TS
XFE_OFC422_n3776 FE_OFN422_n3776 FE_OFN420_n3776 CLKBUFX2TS
XFE_OFC421_n3776 FE_OFN421_n3776 FE_OFN420_n3776 CLKBUFX2TS
XFE_OFC420_n3776 FE_OFN420_n3776 FE_OFN418_n3776 CLKBUFX2TS
XFE_OFC419_n3776 FE_OFN419_n3776 FE_OFN417_n3776 CLKBUFX2TS
XFE_OFC418_n3776 FE_OFN418_n3776 FE_OFN416_n3776 CLKBUFX2TS
XFE_OFC417_n3776 FE_OFN417_n3776 FE_OFN416_n3776 CLKBUFX2TS
XFE_OFC416_n3776 FE_OFN416_n3776 FE_OFN415_n3776 CLKBUFX2TS
XFE_OFC415_n3776 FE_OFN415_n3776 FE_OFN413_n3776 CLKBUFX2TS
XFE_OFC414_n3776 FE_OFN414_n3776 FE_OFN413_n3776 CLKBUFX2TS
XFE_OFC413_n3776 FE_OFN413_n3776 FE_OFN412_n3776 CLKBUFX2TS
XFE_OFC412_n3776 FE_OFN412_n3776 n3776 CLKBUFX2TS
XFE_OFC411_n3777 FE_OFN411_n3777 FE_OFN409_n3777 CLKBUFX2TS
XFE_OFC410_n3777 FE_OFN410_n3777 FE_OFN407_n3777 CLKBUFX2TS
XFE_OFC409_n3777 FE_OFN409_n3777 FE_OFN406_n3777 CLKBUFX2TS
XFE_OFC408_n3777 FE_OFN408_n3777 FE_OFN407_n3777 CLKBUFX2TS
XFE_OFC407_n3777 FE_OFN407_n3777 FE_OFN404_n3777 CLKBUFX2TS
XFE_OFC406_n3777 FE_OFN406_n3777 FE_OFN403_n3777 CLKBUFX2TS
XFE_OFC405_n3777 FE_OFN405_n3777 FE_OFN401_n3777 CLKBUFX2TS
XFE_OFC404_n3777 FE_OFN404_n3777 FE_OFN402_n3777 CLKBUFX2TS
XFE_OFC403_n3777 FE_OFN403_n3777 FE_OFN402_n3777 CLKBUFX2TS
XFE_OFC402_n3777 FE_OFN402_n3777 n3777 CLKBUFX2TS
XFE_OFC401_n3777 FE_OFN401_n3777 n3777 CLKBUFX2TS
XFE_OFC400_n4718 FE_OFN400_n4718 FE_OFN396_n4718 CLKBUFX2TS
XFE_OFC399_n4718 FE_OFN399_n4718 FE_OFN395_n4718 CLKBUFX2TS
XFE_OFC398_n4718 FE_OFN398_n4718 FE_OFN395_n4718 CLKBUFX2TS
XFE_OFC397_n4718 FE_OFN397_n4718 FE_OFN394_n4718 CLKBUFX2TS
XFE_OFC396_n4718 FE_OFN396_n4718 FE_OFN394_n4718 CLKBUFX2TS
XFE_OFC395_n4718 FE_OFN395_n4718 FE_OFN392_n4718 CLKBUFX2TS
XFE_OFC394_n4718 FE_OFN394_n4718 FE_OFN393_n4718 CLKBUFX2TS
XFE_OFC393_n4718 FE_OFN393_n4718 FE_OFN390_n4718 CLKBUFX2TS
XFE_OFC392_n4718 FE_OFN392_n4718 FE_OFN390_n4718 CLKBUFX2TS
XFE_OFC391_n4718 FE_OFN391_n4718 FE_OFN390_n4718 CLKBUFX2TS
XFE_OFC390_n4718 FE_OFN390_n4718 n4718 CLKBUFX2TS
XFE_OFC389_n4730 FE_OFN389_n4730 FE_OFN387_n4730 CLKBUFX2TS
XFE_OFC388_n4730 FE_OFN388_n4730 FE_OFN386_n4730 CLKBUFX2TS
XFE_OFC387_n4730 FE_OFN387_n4730 FE_OFN384_n4730 CLKBUFX2TS
XFE_OFC386_n4730 FE_OFN386_n4730 FE_OFN385_n4730 CLKBUFX2TS
XFE_OFC385_n4730 FE_OFN385_n4730 FE_OFN382_n4730 CLKBUFX2TS
XFE_OFC384_n4730 FE_OFN384_n4730 FE_OFN383_n4730 CLKBUFX2TS
XFE_OFC383_n4730 FE_OFN383_n4730 FE_OFN381_n4730 CLKBUFX2TS
XFE_OFC382_n4730 FE_OFN382_n4730 FE_OFN380_n4730 CLKBUFX2TS
XFE_OFC381_n4730 FE_OFN381_n4730 FE_OFN379_n4730 CLKBUFX2TS
XFE_OFC380_n4730 FE_OFN380_n4730 FE_OFN379_n4730 CLKBUFX2TS
XFE_OFC379_n4730 FE_OFN379_n4730 n4730 CLKBUFX2TS
XFE_OFC378_n4736 FE_OFN378_n4736 FE_OFN376_n4736 CLKBUFX2TS
XFE_OFC377_n4736 FE_OFN377_n4736 FE_OFN375_n4736 CLKBUFX2TS
XFE_OFC376_n4736 FE_OFN376_n4736 FE_OFN374_n4736 CLKBUFX2TS
XFE_OFC375_n4736 FE_OFN375_n4736 FE_OFN373_n4736 CLKBUFX2TS
XFE_OFC374_n4736 FE_OFN374_n4736 FE_OFN371_n4736 CLKBUFX2TS
XFE_OFC373_n4736 FE_OFN373_n4736 FE_OFN372_n4736 CLKBUFX2TS
XFE_OFC372_n4736 FE_OFN372_n4736 FE_OFN370_n4736 CLKBUFX2TS
XFE_OFC371_n4736 FE_OFN371_n4736 FE_OFN369_n4736 CLKBUFX2TS
XFE_OFC370_n4736 FE_OFN370_n4736 n4736 CLKBUFX2TS
XFE_OFC369_n4736 FE_OFN369_n4736 n4736 CLKBUFX2TS
XFE_OFC368_n4748 FE_OFN368_n4748 FE_OFN366_n4748 CLKBUFX2TS
XFE_OFC367_n4748 FE_OFN367_n4748 FE_OFN364_n4748 CLKBUFX2TS
XFE_OFC366_n4748 FE_OFN366_n4748 FE_OFN363_n4748 CLKBUFX2TS
XFE_OFC365_n4748 FE_OFN365_n4748 FE_OFN364_n4748 CLKBUFX2TS
XFE_OFC364_n4748 FE_OFN364_n4748 FE_OFN362_n4748 CLKBUFX2TS
XFE_OFC363_n4748 FE_OFN363_n4748 FE_OFN361_n4748 CLKBUFX2TS
XFE_OFC362_n4748 FE_OFN362_n4748 FE_OFN359_n4748 CLKBUFX2TS
XFE_OFC361_n4748 FE_OFN361_n4748 FE_OFN360_n4748 CLKBUFX2TS
XFE_OFC360_n4748 FE_OFN360_n4748 n4748 CLKBUFX2TS
XFE_OFC359_n4748 FE_OFN359_n4748 n4748 CLKBUFX2TS
XFE_OFC358_n4754 FE_OFN358_n4754 FE_OFN357_n4754 CLKBUFX2TS
XFE_OFC357_n4754 FE_OFN357_n4754 FE_OFN356_n4754 CLKBUFX2TS
XFE_OFC356_n4754 FE_OFN356_n4754 FE_OFN355_n4754 CLKBUFX2TS
XFE_OFC355_n4754 FE_OFN355_n4754 FE_OFN354_n4754 CLKBUFX2TS
XFE_OFC354_n4754 FE_OFN354_n4754 FE_OFN352_n4754 CLKBUFX2TS
XFE_OFC353_n4754 FE_OFN353_n4754 FE_OFN350_n4754 CLKBUFX2TS
XFE_OFC352_n4754 FE_OFN352_n4754 FE_OFN351_n4754 CLKBUFX2TS
XFE_OFC351_n4754 FE_OFN351_n4754 FE_OFN349_n4754 CLKBUFX2TS
XFE_OFC350_n4754 FE_OFN350_n4754 n4754 CLKBUFX2TS
XFE_OFC349_n4754 FE_OFN349_n4754 n4754 CLKBUFX2TS
XFE_OFC348_n4760 FE_OFN348_n4760 FE_OFN345_n4760 CLKBUFX2TS
XFE_OFC347_n4760 FE_OFN347_n4760 FE_OFN345_n4760 CLKBUFX2TS
XFE_OFC346_n4760 FE_OFN346_n4760 FE_OFN343_n4760 CLKBUFX2TS
XFE_OFC345_n4760 FE_OFN345_n4760 FE_OFN342_n4760 CLKBUFX2TS
XFE_OFC344_n4760 FE_OFN344_n4760 FE_OFN343_n4760 CLKBUFX2TS
XFE_OFC343_n4760 FE_OFN343_n4760 FE_OFN339_n4760 CLKBUFX2TS
XFE_OFC342_n4760 FE_OFN342_n4760 FE_OFN338_n4760 CLKBUFX2TS
XFE_OFC341_n4760 FE_OFN341_n4760 FE_OFN339_n4760 CLKBUFX2TS
XFE_OFC340_n4760 FE_OFN340_n4760 FE_OFN338_n4760 CLKBUFX2TS
XFE_OFC339_n4760 FE_OFN339_n4760 n4760 CLKBUFX2TS
XFE_OFC338_n4760 FE_OFN338_n4760 n4760 CLKBUFX2TS
XFE_OFC337_n4573 FE_OFN337_n4573 FE_OFN336_n4573 CLKBUFX2TS
XFE_OFC336_n4573 FE_OFN336_n4573 FE_OFN335_n4573 CLKBUFX2TS
XFE_OFC335_n4573 FE_OFN335_n4573 FE_OFN334_n4573 CLKBUFX2TS
XFE_OFC334_n4573 FE_OFN334_n4573 FE_OFN333_n4573 CLKBUFX2TS
XFE_OFC333_n4573 FE_OFN333_n4573 FE_OFN332_n4573 CLKBUFX2TS
XFE_OFC332_n4573 FE_OFN332_n4573 FE_OFN331_n4573 CLKBUFX2TS
XFE_OFC331_n4573 FE_OFN331_n4573 FE_OFN329_n4573 CLKBUFX2TS
XFE_OFC330_n4573 FE_OFN330_n4573 FE_OFN329_n4573 CLKBUFX2TS
XFE_OFC329_n4573 FE_OFN329_n4573 FE_OFN328_n4573 CLKBUFX2TS
XFE_OFC328_n4573 FE_OFN328_n4573 FE_OFN327_n4573 CLKBUFX2TS
XFE_OFC327_n4573 FE_OFN327_n4573 n4573 CLKBUFX2TS
XFE_OFC326_n8056 FE_OFN326_n8056 FE_OFN325_n8056 CLKBUFX2TS
XFE_OFC325_n8056 FE_OFN325_n8056 n8056 CLKBUFX2TS
XFE_OFC324_n4561 FE_OFN324_n4561 FE_OFN323_n4561 CLKBUFX2TS
XFE_OFC323_n4561 FE_OFN323_n4561 FE_OFN322_n4561 CLKBUFX2TS
XFE_OFC322_n4561 FE_OFN322_n4561 FE_OFN319_n4561 CLKBUFX2TS
XFE_OFC321_n4561 FE_OFN321_n4561 FE_OFN318_n4561 CLKBUFX2TS
XFE_OFC320_n4561 FE_OFN320_n4561 FE_OFN315_n4561 CLKBUFX2TS
XFE_OFC319_n4561 FE_OFN319_n4561 FE_OFN317_n4561 CLKBUFX2TS
XFE_OFC318_n4561 FE_OFN318_n4561 FE_OFN317_n4561 CLKBUFX2TS
XFE_OFC317_n4561 FE_OFN317_n4561 FE_OFN316_n4561 CLKBUFX2TS
XFE_OFC316_n4561 FE_OFN316_n4561 FE_OFN314_n4561 CLKBUFX2TS
XFE_OFC315_n4561 FE_OFN315_n4561 FE_OFN314_n4561 CLKBUFX2TS
XFE_OFC314_n4561 FE_OFN314_n4561 FE_OFN313_n4561 CLKBUFX2TS
XFE_OFC313_n4561 FE_OFN313_n4561 n4561 CLKBUFX2TS
XFE_OFC312_n4555 FE_OFN312_n4555 FE_OFN311_n4555 CLKBUFX2TS
XFE_OFC311_n4555 FE_OFN311_n4555 FE_OFN310_n4555 CLKBUFX2TS
XFE_OFC310_n4555 FE_OFN310_n4555 FE_OFN306_n4555 CLKBUFX2TS
XFE_OFC309_n4555 FE_OFN309_n4555 FE_OFN307_n4555 CLKBUFX2TS
XFE_OFC308_n4555 FE_OFN308_n4555 FE_OFN305_n4555 CLKBUFX2TS
XFE_OFC307_n4555 FE_OFN307_n4555 FE_OFN305_n4555 CLKBUFX2TS
XFE_OFC306_n4555 FE_OFN306_n4555 FE_OFN304_n4555 CLKBUFX2TS
XFE_OFC305_n4555 FE_OFN305_n4555 FE_OFN303_n4555 CLKBUFX2TS
XFE_OFC304_n4555 FE_OFN304_n4555 FE_OFN303_n4555 CLKBUFX2TS
XFE_OFC303_n4555 FE_OFN303_n4555 FE_OFN302_n4555 CLKBUFX2TS
XFE_OFC302_n4555 FE_OFN302_n4555 FE_OFN301_n4555 CLKBUFX2TS
XFE_OFC301_n4555 FE_OFN301_n4555 n4555 CLKBUFX2TS
XFE_OFC300_n4556 FE_OFN300_n4556 FE_OFN298_n4556 CLKBUFX2TS
XFE_OFC299_n4556 FE_OFN299_n4556 FE_OFN294_n4556 CLKBUFX2TS
XFE_OFC298_n4556 FE_OFN298_n4556 FE_OFN294_n4556 CLKBUFX2TS
XFE_OFC297_n4556 FE_OFN297_n4556 FE_OFN293_n4556 CLKBUFX2TS
XFE_OFC296_n4556 FE_OFN296_n4556 FE_OFN293_n4556 CLKBUFX2TS
XFE_OFC295_n4556 FE_OFN295_n4556 FE_OFN292_n4556 CLKBUFX2TS
XFE_OFC294_n4556 FE_OFN294_n4556 FE_OFN291_n4556 CLKBUFX2TS
XFE_OFC293_n4556 FE_OFN293_n4556 FE_OFN292_n4556 CLKBUFX2TS
XFE_OFC292_n4556 FE_OFN292_n4556 FE_OFN291_n4556 CLKBUFX2TS
XFE_OFC291_n4556 FE_OFN291_n4556 n4556 CLKBUFX2TS
XFE_OFC290_n4549 FE_OFN290_n4549 FE_OFN289_n4549 CLKBUFX2TS
XFE_OFC289_n4549 FE_OFN289_n4549 FE_OFN288_n4549 CLKBUFX2TS
XFE_OFC288_n4549 FE_OFN288_n4549 FE_OFN287_n4549 CLKBUFX2TS
XFE_OFC287_n4549 FE_OFN287_n4549 FE_OFN286_n4549 CLKBUFX2TS
XFE_OFC286_n4549 FE_OFN286_n4549 FE_OFN285_n4549 CLKBUFX2TS
XFE_OFC285_n4549 FE_OFN285_n4549 FE_OFN284_n4549 CLKBUFX2TS
XFE_OFC284_n4549 FE_OFN284_n4549 FE_OFN283_n4549 CLKBUFX2TS
XFE_OFC283_n4549 FE_OFN283_n4549 FE_OFN282_n4549 CLKBUFX2TS
XFE_OFC282_n4549 FE_OFN282_n4549 FE_OFN280_n4549 CLKBUFX2TS
XFE_OFC281_n4549 FE_OFN281_n4549 FE_OFN279_n4549 CLKBUFX2TS
XFE_OFC280_n4549 FE_OFN280_n4549 FE_OFN279_n4549 CLKBUFX2TS
XFE_OFC279_n4549 FE_OFN279_n4549 n4549 CLKBUFX2TS
XFE_OFC278_n4543 FE_OFN278_n4543 FE_OFN276_n4543 CLKBUFX2TS
XFE_OFC277_n4543 FE_OFN277_n4543 FE_OFN275_n4543 CLKBUFX2TS
XFE_OFC276_n4543 FE_OFN276_n4543 FE_OFN273_n4543 CLKBUFX2TS
XFE_OFC275_n4543 FE_OFN275_n4543 FE_OFN271_n4543 CLKBUFX2TS
XFE_OFC274_n4543 FE_OFN274_n4543 FE_OFN273_n4543 CLKBUFX2TS
XFE_OFC273_n4543 FE_OFN273_n4543 FE_OFN270_n4543 CLKBUFX2TS
XFE_OFC272_n4543 FE_OFN272_n4543 FE_OFN268_n4543 CLKBUFX2TS
XFE_OFC271_n4543 FE_OFN271_n4543 FE_OFN269_n4543 CLKBUFX2TS
XFE_OFC270_n4543 FE_OFN270_n4543 FE_OFN269_n4543 CLKBUFX2TS
XFE_OFC269_n4543 FE_OFN269_n4543 FE_OFN267_n4543 CLKBUFX2TS
XFE_OFC268_n4543 FE_OFN268_n4543 FE_OFN266_n4543 CLKBUFX2TS
XFE_OFC267_n4543 FE_OFN267_n4543 FE_OFN266_n4543 CLKBUFX2TS
XFE_OFC266_n4543 FE_OFN266_n4543 n4543 CLKBUFX2TS
XFE_OFC265_n4544 FE_OFN265_n4544 FE_OFN264_n4544 CLKBUFX2TS
XFE_OFC264_n4544 FE_OFN264_n4544 FE_OFN263_n4544 CLKBUFX2TS
XFE_OFC263_n4544 FE_OFN263_n4544 FE_OFN262_n4544 CLKBUFX2TS
XFE_OFC262_n4544 FE_OFN262_n4544 FE_OFN259_n4544 CLKBUFX2TS
XFE_OFC261_n4544 FE_OFN261_n4544 FE_OFN260_n4544 CLKBUFX2TS
XFE_OFC260_n4544 FE_OFN260_n4544 FE_OFN257_n4544 CLKBUFX2TS
XFE_OFC259_n4544 FE_OFN259_n4544 FE_OFN258_n4544 CLKBUFX2TS
XFE_OFC258_n4544 FE_OFN258_n4544 FE_OFN256_n4544 CLKBUFX2TS
XFE_OFC257_n4544 FE_OFN257_n4544 n4544 CLKBUFX2TS
XFE_OFC256_n4544 FE_OFN256_n4544 n4544 CLKBUFX2TS
XFE_OFC255_n4537 FE_OFN255_n4537 FE_OFN254_n4537 CLKBUFX2TS
XFE_OFC254_n4537 FE_OFN254_n4537 FE_OFN253_n4537 CLKBUFX2TS
XFE_OFC253_n4537 FE_OFN253_n4537 FE_OFN252_n4537 CLKBUFX2TS
XFE_OFC252_n4537 FE_OFN252_n4537 FE_OFN251_n4537 CLKBUFX2TS
XFE_OFC251_n4537 FE_OFN251_n4537 FE_OFN248_n4537 CLKBUFX2TS
XFE_OFC250_n4537 FE_OFN250_n4537 FE_OFN248_n4537 CLKBUFX2TS
XFE_OFC249_n4537 FE_OFN249_n4537 FE_OFN246_n4537 CLKBUFX2TS
XFE_OFC248_n4537 FE_OFN248_n4537 FE_OFN245_n4537 CLKBUFX2TS
XFE_OFC247_n4537 FE_OFN247_n4537 FE_OFN245_n4537 CLKBUFX2TS
XFE_OFC246_n4537 FE_OFN246_n4537 FE_OFN244_n4537 CLKBUFX2TS
XFE_OFC245_n4537 FE_OFN245_n4537 n4537 CLKBUFX2TS
XFE_OFC244_n4537 FE_OFN244_n4537 n4537 CLKBUFX2TS
XFE_OFC243_n4531 FE_OFN243_n4531 FE_OFN242_n4531 CLKBUFX2TS
XFE_OFC242_n4531 FE_OFN242_n4531 FE_OFN238_n4531 CLKBUFX2TS
XFE_OFC241_n4531 FE_OFN241_n4531 FE_OFN239_n4531 CLKBUFX2TS
XFE_OFC240_n4531 FE_OFN240_n4531 FE_OFN239_n4531 CLKBUFX2TS
XFE_OFC239_n4531 FE_OFN239_n4531 FE_OFN236_n4531 CLKBUFX2TS
XFE_OFC238_n4531 FE_OFN238_n4531 FE_OFN236_n4531 CLKBUFX2TS
XFE_OFC237_n4531 FE_OFN237_n4531 FE_OFN234_n4531 CLKBUFX2TS
XFE_OFC236_n4531 FE_OFN236_n4531 FE_OFN235_n4531 CLKBUFX2TS
XFE_OFC235_n4531 FE_OFN235_n4531 FE_OFN233_n4531 CLKBUFX2TS
XFE_OFC234_n4531 FE_OFN234_n4531 FE_OFN232_n4531 CLKBUFX2TS
XFE_OFC233_n4531 FE_OFN233_n4531 n4531 CLKBUFX2TS
XFE_OFC232_n4531 FE_OFN232_n4531 n4531 CLKBUFX2TS
XFE_OFC231_n4525 FE_OFN231_n4525 FE_OFN230_n4525 CLKBUFX2TS
XFE_OFC230_n4525 FE_OFN230_n4525 FE_OFN229_n4525 CLKBUFX2TS
XFE_OFC229_n4525 FE_OFN229_n4525 FE_OFN227_n4525 CLKBUFX2TS
XFE_OFC228_n4525 FE_OFN228_n4525 FE_OFN227_n4525 CLKBUFX2TS
XFE_OFC227_n4525 FE_OFN227_n4525 FE_OFN225_n4525 CLKBUFX2TS
XFE_OFC226_n4525 FE_OFN226_n4525 FE_OFN223_n4525 CLKBUFX2TS
XFE_OFC225_n4525 FE_OFN225_n4525 FE_OFN223_n4525 CLKBUFX2TS
XFE_OFC224_n4525 FE_OFN224_n4525 FE_OFN222_n4525 CLKBUFX2TS
XFE_OFC223_n4525 FE_OFN223_n4525 FE_OFN222_n4525 CLKBUFX2TS
XFE_OFC222_n4525 FE_OFN222_n4525 FE_OFN221_n4525 CLKBUFX2TS
XFE_OFC221_n4525 FE_OFN221_n4525 n4525 CLKBUFX2TS
XFE_OFC220_n4519 FE_OFN220_n4519 FE_OFN219_n4519 CLKBUFX2TS
XFE_OFC219_n4519 FE_OFN219_n4519 FE_OFN216_n4519 CLKBUFX2TS
XFE_OFC218_n4519 FE_OFN218_n4519 FE_OFN215_n4519 CLKBUFX2TS
XFE_OFC217_n4519 FE_OFN217_n4519 FE_OFN215_n4519 CLKBUFX2TS
XFE_OFC216_n4519 FE_OFN216_n4519 FE_OFN214_n4519 CLKBUFX2TS
XFE_OFC215_n4519 FE_OFN215_n4519 FE_OFN213_n4519 CLKBUFX2TS
XFE_OFC214_n4519 FE_OFN214_n4519 FE_OFN211_n4519 CLKBUFX2TS
XFE_OFC213_n4519 FE_OFN213_n4519 FE_OFN212_n4519 CLKBUFX2TS
XFE_OFC212_n4519 FE_OFN212_n4519 FE_OFN210_n4519 CLKBUFX2TS
XFE_OFC211_n4519 FE_OFN211_n4519 FE_OFN210_n4519 CLKBUFX2TS
XFE_OFC210_n4519 FE_OFN210_n4519 n4519 CLKBUFX2TS
XFE_OFC209_n4519 FE_OFN209_n4519 n4519 CLKBUFX2TS
XFE_OFC208_n4513 FE_OFN208_n4513 FE_OFN207_n4513 CLKBUFX2TS
XFE_OFC207_n4513 FE_OFN207_n4513 FE_OFN204_n4513 CLKBUFX2TS
XFE_OFC206_n4513 FE_OFN206_n4513 FE_OFN203_n4513 CLKBUFX2TS
XFE_OFC205_n4513 FE_OFN205_n4513 FE_OFN203_n4513 CLKBUFX2TS
XFE_OFC204_n4513 FE_OFN204_n4513 FE_OFN201_n4513 CLKBUFX2TS
XFE_OFC203_n4513 FE_OFN203_n4513 FE_OFN202_n4513 CLKBUFX2TS
XFE_OFC202_n4513 FE_OFN202_n4513 FE_OFN200_n4513 CLKBUFX2TS
XFE_OFC201_n4513 FE_OFN201_n4513 FE_OFN200_n4513 CLKBUFX2TS
XFE_OFC200_n4513 FE_OFN200_n4513 FE_OFN197_n4513 CLKBUFX2TS
XFE_OFC199_n4513 FE_OFN199_n4513 FE_OFN198_n4513 CLKBUFX2TS
XFE_OFC198_n4513 FE_OFN198_n4513 n4513 CLKBUFX2TS
XFE_OFC197_n4513 FE_OFN197_n4513 n4513 CLKBUFX2TS
XFE_OFC196_n4514 FE_OFN196_n4514 FE_OFN195_n4514 CLKBUFX2TS
XFE_OFC195_n4514 FE_OFN195_n4514 FE_OFN192_n4514 CLKBUFX2TS
XFE_OFC194_n4514 FE_OFN194_n4514 FE_OFN193_n4514 CLKBUFX2TS
XFE_OFC193_n4514 FE_OFN193_n4514 FE_OFN190_n4514 CLKBUFX2TS
XFE_OFC192_n4514 FE_OFN192_n4514 FE_OFN191_n4514 CLKBUFX2TS
XFE_OFC191_n4514 FE_OFN191_n4514 FE_OFN189_n4514 CLKBUFX2TS
XFE_OFC190_n4514 FE_OFN190_n4514 FE_OFN188_n4514 CLKBUFX2TS
XFE_OFC189_n4514 FE_OFN189_n4514 FE_OFN187_n4514 CLKBUFX2TS
XFE_OFC188_n4514 FE_OFN188_n4514 n4514 CLKBUFX2TS
XFE_OFC187_n4514 FE_OFN187_n4514 n4514 CLKBUFX2TS
XFE_OFC186_n4507 FE_OFN186_n4507 FE_OFN185_n4507 CLKBUFX2TS
XFE_OFC185_n4507 FE_OFN185_n4507 FE_OFN184_n4507 CLKBUFX2TS
XFE_OFC184_n4507 FE_OFN184_n4507 FE_OFN182_n4507 CLKBUFX2TS
XFE_OFC183_n4507 FE_OFN183_n4507 FE_OFN181_n4507 CLKBUFX2TS
XFE_OFC182_n4507 FE_OFN182_n4507 FE_OFN179_n4507 CLKBUFX2TS
XFE_OFC181_n4507 FE_OFN181_n4507 FE_OFN180_n4507 CLKBUFX2TS
XFE_OFC180_n4507 FE_OFN180_n4507 FE_OFN177_n4507 CLKBUFX2TS
XFE_OFC179_n4507 FE_OFN179_n4507 FE_OFN178_n4507 CLKBUFX2TS
XFE_OFC178_n4507 FE_OFN178_n4507 FE_OFN176_n4507 CLKBUFX2TS
XFE_OFC177_n4507 FE_OFN177_n4507 FE_OFN176_n4507 CLKBUFX2TS
XFE_OFC176_n4507 FE_OFN176_n4507 FE_OFN175_n4507 CLKBUFX2TS
XFE_OFC175_n4507 FE_OFN175_n4507 n4507 CLKBUFX2TS
XFE_OFC174_n8054 FE_OFN174_n8054 FE_OFN173_n8054 CLKBUFX2TS
XFE_OFC173_n8054 FE_OFN173_n8054 n8054 CLKBUFX2TS
XFE_OFC172_n4495 FE_OFN172_n4495 FE_OFN171_n4495 CLKBUFX2TS
XFE_OFC171_n4495 FE_OFN171_n4495 FE_OFN170_n4495 CLKBUFX2TS
XFE_OFC170_n4495 FE_OFN170_n4495 FE_OFN168_n4495 CLKBUFX2TS
XFE_OFC169_n4495 FE_OFN169_n4495 FE_OFN167_n4495 CLKBUFX2TS
XFE_OFC168_n4495 FE_OFN168_n4495 FE_OFN166_n4495 CLKBUFX2TS
XFE_OFC167_n4495 FE_OFN167_n4495 FE_OFN165_n4495 CLKBUFX2TS
XFE_OFC166_n4495 FE_OFN166_n4495 FE_OFN164_n4495 CLKBUFX2TS
XFE_OFC165_n4495 FE_OFN165_n4495 FE_OFN163_n4495 CLKBUFX2TS
XFE_OFC164_n4495 FE_OFN164_n4495 FE_OFN163_n4495 CLKBUFX2TS
XFE_OFC163_n4495 FE_OFN163_n4495 FE_OFN162_n4495 CLKBUFX2TS
XFE_OFC162_n4495 FE_OFN162_n4495 FE_OFN161_n4495 CLKBUFX2TS
XFE_OFC161_n4495 FE_OFN161_n4495 n4495 CLKBUFX2TS
XFE_OFC160_n4496 FE_OFN160_n4496 FE_OFN157_n4496 CLKBUFX2TS
XFE_OFC159_n4496 FE_OFN159_n4496 FE_OFN156_n4496 CLKBUFX2TS
XFE_OFC158_n4496 FE_OFN158_n4496 FE_OFN156_n4496 CLKBUFX2TS
XFE_OFC157_n4496 FE_OFN157_n4496 FE_OFN155_n4496 CLKBUFX2TS
XFE_OFC156_n4496 FE_OFN156_n4496 FE_OFN154_n4496 CLKBUFX2TS
XFE_OFC155_n4496 FE_OFN155_n4496 FE_OFN153_n4496 CLKBUFX2TS
XFE_OFC154_n4496 FE_OFN154_n4496 FE_OFN152_n4496 CLKBUFX2TS
XFE_OFC153_n4496 FE_OFN153_n4496 FE_OFN152_n4496 CLKBUFX2TS
XFE_OFC152_n4496 FE_OFN152_n4496 FE_OFN151_n4496 CLKBUFX2TS
XFE_OFC151_n4496 FE_OFN151_n4496 n4496 CLKBUFX2TS
XFE_OFC150_n4489 FE_OFN150_n4489 FE_OFN149_n4489 CLKBUFX2TS
XFE_OFC149_n4489 FE_OFN149_n4489 FE_OFN148_n4489 CLKBUFX2TS
XFE_OFC148_n4489 FE_OFN148_n4489 FE_OFN147_n4489 CLKBUFX2TS
XFE_OFC147_n4489 FE_OFN147_n4489 FE_OFN146_n4489 CLKBUFX2TS
XFE_OFC146_n4489 FE_OFN146_n4489 FE_OFN144_n4489 CLKBUFX2TS
XFE_OFC145_n4489 FE_OFN145_n4489 FE_OFN143_n4489 CLKBUFX2TS
XFE_OFC144_n4489 FE_OFN144_n4489 FE_OFN141_n4489 CLKBUFX2TS
XFE_OFC143_n4489 FE_OFN143_n4489 FE_OFN142_n4489 CLKBUFX2TS
XFE_OFC142_n4489 FE_OFN142_n4489 FE_OFN140_n4489 CLKBUFX2TS
XFE_OFC141_n4489 FE_OFN141_n4489 FE_OFN140_n4489 CLKBUFX2TS
XFE_OFC140_n4489 FE_OFN140_n4489 FE_OFN139_n4489 CLKBUFX2TS
XFE_OFC139_n4489 FE_OFN139_n4489 n4489 CLKBUFX2TS
XFE_OFC138_n4490 FE_OFN138_n4490 FE_OFN137_n4490 CLKBUFX2TS
XFE_OFC137_n4490 FE_OFN137_n4490 FE_OFN136_n4490 CLKBUFX2TS
XFE_OFC136_n4490 FE_OFN136_n4490 FE_OFN135_n4490 CLKBUFX2TS
XFE_OFC135_n4490 FE_OFN135_n4490 FE_OFN134_n4490 CLKBUFX2TS
XFE_OFC134_n4490 FE_OFN134_n4490 FE_OFN132_n4490 CLKBUFX2TS
XFE_OFC133_n4490 FE_OFN133_n4490 FE_OFN131_n4490 CLKBUFX2TS
XFE_OFC132_n4490 FE_OFN132_n4490 FE_OFN131_n4490 CLKBUFX2TS
XFE_OFC131_n4490 FE_OFN131_n4490 FE_OFN130_n4490 CLKBUFX2TS
XFE_OFC130_n4490 FE_OFN130_n4490 FE_OFN129_n4490 CLKBUFX2TS
XFE_OFC129_n4490 FE_OFN129_n4490 n4490 CLKBUFX2TS
XFE_OFC128_n4502 FE_OFN128_n4502 FE_OFN127_n4502 CLKBUFX2TS
XFE_OFC127_n4502 FE_OFN127_n4502 FE_OFN126_n4502 CLKBUFX2TS
XFE_OFC126_n4502 FE_OFN126_n4502 FE_OFN125_n4502 CLKBUFX2TS
XFE_OFC125_n4502 FE_OFN125_n4502 FE_OFN123_n4502 CLKBUFX2TS
XFE_OFC124_n4502 FE_OFN124_n4502 FE_OFN121_n4502 CLKINVX1TS
XFE_OFC123_n4502 FE_OFN123_n4502 FE_OFN121_n4502 CLKINVX1TS
XFE_OFC122_n4502 FE_OFN122_n4502 FE_OFN119_n4502 CLKBUFX2TS
XFE_OFC121_n4502 FE_OFN121_n4502 FE_OFN116_n4502 CLKINVX1TS
XFE_OFC120_n4502 FE_OFN120_n4502 FE_OFN117_n4502 CLKINVX1TS
XFE_OFC119_n4502 FE_OFN119_n4502 FE_OFN117_n4502 CLKINVX1TS
XFE_OFC118_n4502 FE_OFN118_n4502 FE_OFN116_n4502 CLKBUFX2TS
XFE_OFC117_n4502 FE_OFN117_n4502 FE_OFN115_n4502 CLKINVX1TS
XFE_OFC116_n4502 FE_OFN116_n4502 FE_OFN115_n4502 CLKBUFX2TS
XFE_OFC115_n4502 FE_OFN115_n4502 n4502 CLKBUFX2TS
XFE_OFC114_n4508 FE_OFN114_n4508 FE_OFN113_n4508 CLKBUFX2TS
XFE_OFC113_n4508 FE_OFN113_n4508 FE_OFN111_n4508 CLKBUFX2TS
XFE_OFC112_n4508 FE_OFN112_n4508 FE_OFN110_n4508 CLKBUFX2TS
XFE_OFC111_n4508 FE_OFN111_n4508 FE_OFN109_n4508 CLKBUFX2TS
XFE_OFC110_n4508 FE_OFN110_n4508 FE_OFN108_n4508 CLKBUFX2TS
XFE_OFC109_n4508 FE_OFN109_n4508 FE_OFN107_n4508 CLKBUFX2TS
XFE_OFC108_n4508 FE_OFN108_n4508 FE_OFN106_n4508 CLKBUFX2TS
XFE_OFC107_n4508 FE_OFN107_n4508 FE_OFN105_n4508 CLKBUFX2TS
XFE_OFC106_n4508 FE_OFN106_n4508 n4508 CLKBUFX2TS
XFE_OFC105_n4508 FE_OFN105_n4508 n4508 CLKBUFX2TS
XFE_OFC104_n4520 FE_OFN104_n4520 FE_OFN103_n4520 CLKBUFX2TS
XFE_OFC103_n4520 FE_OFN103_n4520 FE_OFN102_n4520 CLKBUFX2TS
XFE_OFC102_n4520 FE_OFN102_n4520 FE_OFN99_n4520 CLKBUFX2TS
XFE_OFC101_n4520 FE_OFN101_n4520 FE_OFN98_n4520 CLKBUFX2TS
XFE_OFC100_n4520 FE_OFN100_n4520 FE_OFN98_n4520 CLKBUFX2TS
XFE_OFC99_n4520 FE_OFN99_n4520 FE_OFN96_n4520 CLKBUFX2TS
XFE_OFC98_n4520 FE_OFN98_n4520 FE_OFN95_n4520 CLKBUFX2TS
XFE_OFC97_n4520 FE_OFN97_n4520 FE_OFN95_n4520 CLKBUFX2TS
XFE_OFC96_n4520 FE_OFN96_n4520 n4520 CLKBUFX2TS
XFE_OFC95_n4520 FE_OFN95_n4520 n4520 CLKBUFX2TS
XFE_OFC94_n4526 FE_OFN94_n4526 FE_OFN93_n4526 CLKBUFX2TS
XFE_OFC93_n4526 FE_OFN93_n4526 FE_OFN92_n4526 CLKBUFX2TS
XFE_OFC92_n4526 FE_OFN92_n4526 FE_OFN91_n4526 CLKBUFX2TS
XFE_OFC91_n4526 FE_OFN91_n4526 FE_OFN90_n4526 CLKBUFX2TS
XFE_OFC90_n4526 FE_OFN90_n4526 FE_OFN87_n4526 CLKBUFX2TS
XFE_OFC89_n4526 FE_OFN89_n4526 FE_OFN86_n4526 CLKBUFX2TS
XFE_OFC88_n4526 FE_OFN88_n4526 FE_OFN86_n4526 CLKBUFX2TS
XFE_OFC87_n4526 FE_OFN87_n4526 FE_OFN84_n4526 CLKBUFX2TS
XFE_OFC86_n4526 FE_OFN86_n4526 FE_OFN84_n4526 CLKBUFX2TS
XFE_OFC85_n4526 FE_OFN85_n4526 n4526 CLKBUFX2TS
XFE_OFC84_n4526 FE_OFN84_n4526 n4526 CLKBUFX2TS
XFE_OFC83_n3796 FE_OFN83_n3796 FE_OFN81_n3796 CLKBUFX2TS
XFE_OFC82_n3796 FE_OFN82_n3796 FE_OFN80_n3796 CLKBUFX2TS
XFE_OFC81_n3796 FE_OFN81_n3796 FE_OFN79_n3796 CLKBUFX2TS
XFE_OFC80_n3796 FE_OFN80_n3796 FE_OFN78_n3796 CLKBUFX2TS
XFE_OFC79_n3796 FE_OFN79_n3796 FE_OFN77_n3796 CLKBUFX2TS
XFE_OFC78_n3796 FE_OFN78_n3796 FE_OFN76_n3796 CLKBUFX2TS
XFE_OFC77_n3796 FE_OFN77_n3796 FE_OFN75_n3796 CLKBUFX2TS
XFE_OFC76_n3796 FE_OFN76_n3796 FE_OFN75_n3796 CLKBUFX2TS
XFE_OFC75_n3796 FE_OFN75_n3796 FE_OFN74_n3796 CLKBUFX2TS
XFE_OFC74_n3796 FE_OFN74_n3796 FE_OFN73_n3796 CLKBUFX2TS
XFE_OFC73_n3796 FE_OFN73_n3796 n3796 CLKBUFX2TS
XFE_OFC72_n3797 FE_OFN72_n3797 FE_OFN70_n3797 CLKBUFX2TS
XFE_OFC71_n3797 FE_OFN71_n3797 FE_OFN69_n3797 CLKBUFX2TS
XFE_OFC70_n3797 FE_OFN70_n3797 FE_OFN68_n3797 CLKBUFX2TS
XFE_OFC69_n3797 FE_OFN69_n3797 FE_OFN67_n3797 CLKBUFX2TS
XFE_OFC68_n3797 FE_OFN68_n3797 FE_OFN66_n3797 CLKBUFX2TS
XFE_OFC67_n3797 FE_OFN67_n3797 FE_OFN65_n3797 CLKBUFX2TS
XFE_OFC66_n3797 FE_OFN66_n3797 FE_OFN64_n3797 CLKBUFX2TS
XFE_OFC65_n3797 FE_OFN65_n3797 FE_OFN64_n3797 CLKBUFX2TS
XFE_OFC64_n3797 FE_OFN64_n3797 FE_OFN63_n3797 CLKBUFX2TS
XFE_OFC63_n3797 FE_OFN63_n3797 n3797 CLKBUFX2TS
XFE_OFC62_n4532 FE_OFN62_n4532 FE_OFN61_n4532 CLKBUFX2TS
XFE_OFC61_n4532 FE_OFN61_n4532 FE_OFN58_n4532 CLKBUFX2TS
XFE_OFC60_n4532 FE_OFN60_n4532 FE_OFN57_n4532 CLKBUFX2TS
XFE_OFC59_n4532 FE_OFN59_n4532 FE_OFN56_n4532 CLKBUFX2TS
XFE_OFC58_n4532 FE_OFN58_n4532 FE_OFN55_n4532 CLKBUFX2TS
XFE_OFC57_n4532 FE_OFN57_n4532 FE_OFN55_n4532 CLKBUFX2TS
XFE_OFC56_n4532 FE_OFN56_n4532 FE_OFN54_n4532 CLKBUFX2TS
XFE_OFC55_n4532 FE_OFN55_n4532 FE_OFN53_n4532 CLKBUFX2TS
XFE_OFC54_n4532 FE_OFN54_n4532 FE_OFN53_n4532 CLKBUFX2TS
XFE_OFC53_n4532 FE_OFN53_n4532 n4532 CLKBUFX2TS
XFE_OFC52_n4538 FE_OFN52_n4538 FE_OFN51_n4538 CLKBUFX2TS
XFE_OFC51_n4538 FE_OFN51_n4538 FE_OFN49_n4538 CLKBUFX2TS
XFE_OFC50_n4538 FE_OFN50_n4538 FE_OFN48_n4538 CLKBUFX2TS
XFE_OFC49_n4538 FE_OFN49_n4538 FE_OFN47_n4538 CLKBUFX2TS
XFE_OFC48_n4538 FE_OFN48_n4538 FE_OFN46_n4538 CLKBUFX2TS
XFE_OFC47_n4538 FE_OFN47_n4538 FE_OFN45_n4538 CLKBUFX2TS
XFE_OFC46_n4538 FE_OFN46_n4538 FE_OFN43_n4538 CLKBUFX2TS
XFE_OFC45_n4538 FE_OFN45_n4538 FE_OFN44_n4538 CLKBUFX2TS
XFE_OFC44_n4538 FE_OFN44_n4538 n4538 CLKBUFX2TS
XFE_OFC43_n4538 FE_OFN43_n4538 n4538 CLKBUFX2TS
XFE_OFC42_n4550 FE_OFN42_n4550 FE_OFN40_n4550 CLKBUFX2TS
XFE_OFC41_n4550 FE_OFN41_n4550 FE_OFN40_n4550 CLKBUFX2TS
XFE_OFC40_n4550 FE_OFN40_n4550 FE_OFN39_n4550 CLKBUFX2TS
XFE_OFC39_n4550 FE_OFN39_n4550 FE_OFN38_n4550 CLKBUFX2TS
XFE_OFC38_n4550 FE_OFN38_n4550 FE_OFN37_n4550 CLKBUFX2TS
XFE_OFC37_n4550 FE_OFN37_n4550 FE_OFN36_n4550 CLKBUFX2TS
XFE_OFC36_n4550 FE_OFN36_n4550 FE_OFN35_n4550 CLKBUFX2TS
XFE_OFC35_n4550 FE_OFN35_n4550 FE_OFN34_n4550 CLKBUFX2TS
XFE_OFC34_n4550 FE_OFN34_n4550 FE_OFN33_n4550 CLKBUFX2TS
XFE_OFC33_n4550 FE_OFN33_n4550 n4550 CLKBUFX2TS
XFE_OFC32_n4562 FE_OFN32_n4562 FE_OFN30_n4562 CLKBUFX2TS
XFE_OFC31_n4562 FE_OFN31_n4562 FE_OFN30_n4562 CLKBUFX2TS
XFE_OFC30_n4562 FE_OFN30_n4562 FE_OFN29_n4562 CLKBUFX2TS
XFE_OFC29_n4562 FE_OFN29_n4562 FE_OFN27_n4562 CLKBUFX2TS
XFE_OFC28_n4562 FE_OFN28_n4562 FE_OFN26_n4562 CLKBUFX2TS
XFE_OFC27_n4562 FE_OFN27_n4562 FE_OFN26_n4562 CLKBUFX2TS
XFE_OFC26_n4562 FE_OFN26_n4562 FE_OFN23_n4562 CLKBUFX2TS
XFE_OFC25_n4562 FE_OFN25_n4562 FE_OFN24_n4562 CLKBUFX2TS
XFE_OFC24_n4562 FE_OFN24_n4562 FE_OFN22_n4562 CLKBUFX2TS
XFE_OFC23_n4562 FE_OFN23_n4562 n4562 CLKBUFX2TS
XFE_OFC22_n4562 FE_OFN22_n4562 n4562 CLKBUFX2TS
XFE_OFC21_n4568 FE_OFN21_n4568 FE_OFN20_n4568 CLKBUFX2TS
XFE_OFC20_n4568 FE_OFN20_n4568 FE_OFN18_n4568 CLKBUFX2TS
XFE_OFC19_n4568 FE_OFN19_n4568 FE_OFN17_n4568 CLKBUFX2TS
XFE_OFC18_n4568 FE_OFN18_n4568 FE_OFN17_n4568 CLKBUFX2TS
XFE_OFC17_n4568 FE_OFN17_n4568 FE_OFN16_n4568 CLKBUFX2TS
XFE_OFC16_n4568 FE_OFN16_n4568 FE_OFN15_n4568 CLKBUFX2TS
XFE_OFC15_n4568 FE_OFN15_n4568 FE_OFN13_n4568 CLKBUFX2TS
XFE_OFC14_n4568 FE_OFN14_n4568 FE_OFN12_n4568 CLKINVX1TS
XFE_OFC13_n4568 FE_OFN13_n4568 FE_OFN12_n4568 CLKINVX1TS
XFE_OFC12_n4568 FE_OFN12_n4568 FE_OFN11_n4568 CLKINVX1TS
XFE_OFC11_n4568 FE_OFN11_n4568 FE_OFN10_n4568 CLKBUFX2TS
XFE_OFC10_n4568 FE_OFN10_n4568 n4568 CLKBUFX2TS
XFE_OFC9_n4574 FE_OFN9_n4574 FE_OFN8_n4574 CLKBUFX2TS
XFE_OFC8_n4574 FE_OFN8_n4574 FE_OFN7_n4574 CLKBUFX2TS
XFE_OFC7_n4574 FE_OFN7_n4574 FE_OFN6_n4574 CLKBUFX2TS
XFE_OFC6_n4574 FE_OFN6_n4574 FE_OFN5_n4574 CLKBUFX2TS
XFE_OFC5_n4574 FE_OFN5_n4574 FE_OFN4_n4574 CLKBUFX2TS
XFE_OFC4_n4574 FE_OFN4_n4574 FE_OFN3_n4574 CLKBUFX2TS
XFE_OFC3_n4574 FE_OFN3_n4574 FE_OFN2_n4574 CLKBUFX2TS
XFE_OFC2_n4574 FE_OFN2_n4574 FE_OFN1_n4574 CLKBUFX2TS
XFE_OFC1_n4574 FE_OFN1_n4574 FE_OFN0_n4574 CLKBUFX2TS
XFE_OFC0_n4574 FE_OFN0_n4574 n4574 CLKBUFX2TS
XFE_MDBC14_U5721 FE_MDBN14_ fft_data_in[31] BUFX2TS
XFE_MDBC13_U5679 FE_MDBN13_ fft_data_in[30] BUFX2TS
XFE_MDBC12_U5586 FE_MDBN12_ fft_data_in[29] BUFX2TS
XFE_MDBC11_U5490 FE_MDBN11_ fft_data_in[28] BUFX2TS
XFE_MDBC10_U5445 FE_MDBN10_ fft_data_in[27] BUFX2TS
XFE_MDBC9_U5223 FE_MDBN9_ fft_data_in[26] BUFX2TS
XFE_MDBC8_U5221 FE_MDBN8_ fft_data_in[24] BUFX2TS
XFE_MDBC7_U5210 FE_MDBN7_ fft_data_in[5] BUFX2TS
XFE_MDBC6_U5209 FE_MDBN6_ fft_data_in[3] BUFX2TS
XFE_MDBC5_U5208 FE_MDBN5_ fft_data_in[2] BUFX2TS
XFE_MDBC4_U5719 FE_MDBN4_ fft_data_in[1] BUFX2TS
XFE_MDBC3_U5677 FE_MDBN3_ fft_data_in[0] BUFX2TS
XFE_MDBC2_U5721 FE_MDBN2_ fir_data_in[31] BUFX2TS
XFE_MDBC1_U5586 FE_MDBN1_ fir_data_in[29] BUFX2TS
XFE_MDBC0_U5490 FE_MDBN0_ fir_data_in[28] BUFX2TS
Xmips_mips_a_accbypassA_reg acc_bypass 1000 clk__L1_N0 n3440 n4444 DFFTRX1TS
Xmips_mips_a_fullinstructionA_reg[31] instruction[31] 1001 clk__L1_N0
+ mips_mips_accfullinstruction[31] n9370 DFFTRX1TS
Xmips_mips_a_fullinstructionA_reg[30] instruction[30] 1002 clk__L1_N0
+ mips_mips_accfullinstruction[30] n9370 DFFTRX1TS
Xmips_mips_a_fullinstructionA_reg[29] instruction[29] 1003 clk__L1_N0
+ mips_mips_accfullinstruction[29] n9370 DFFTRX1TS
Xmips_mips_a_fullinstructionA_reg[28] instruction[28] 1004 clk__L1_N0
+ mips_mips_accfullinstruction[28] n9371 DFFTRX1TS
Xmips_mips_a_fullinstructionA_reg[27] instruction[27] 1005 clk__L1_N0
+ mips_mips_accfullinstruction[27] n9371 DFFTRX1TS
Xmips_mips_a_fullinstructionA_reg[26] instruction[26] 1006 clk__L1_N0
+ mips_mips_accfullinstruction[26] n9371 DFFTRX1TS
Xmips_mips_a_fullinstructionA_reg[0] instruction[0] 1007 clk__L1_N0
+ mips_mips_accfullinstruction[0] n9371 DFFTRX1TS
Xmips_mips_a_fullinstructionA_reg[1] instruction[1] n3455 clk__L1_N0
+ mips_mips_accfullinstruction[1] n9372 DFFTRX1TS
Xmips_mips_a_fullinstructionA_reg[2] instruction[2] 1008 clk__L1_N0
+ mips_mips_accfullinstruction[2] n9372 DFFTRX1TS
Xmips_mips_a_fullinstructionA_reg[3] instruction[3] 1009 clk__L1_N0
+ mips_mips_accfullinstruction[3] n9372 DFFTRX1TS
Xmips_mips_a_fullinstructionA_reg[4] instruction[4] 1010 clk__L1_N0
+ mips_mips_accfullinstruction[4] n9372 DFFTRX1TS
Xmips_mips_a_fullinstructionA_reg[5] instruction[5] 1011 clk__L1_N0
+ mips_mips_accfullinstruction[5] n9373 DFFTRX1TS
Xmips_mips_a_fullinstructionA_reg[6] instruction[6] 1012 clk__L1_N0
+ mips_mips_accfullinstruction[6] n9373 DFFTRX1TS
Xmips_mips_a_fullinstructionA_reg[7] instruction[7] 1013 clk__L1_N0
+ mips_mips_accfullinstruction[7] n9373 DFFTRX1TS
Xmips_mips_a_fullinstructionA_reg[8] instruction[8] 1014 clk__L1_N0
+ mips_mips_accfullinstruction[8] n9373 DFFTRX1TS
Xmips_mips_a_fullinstructionA_reg[9] instruction[9] 1015 clk__L1_N0
+ mips_mips_accfullinstruction[9] n9374 DFFTRX1TS
Xmips_mips_a_fullinstructionA_reg[10] instruction[10] 1016 clk__L1_N0
+ mips_mips_accfullinstruction[10] n9374 DFFTRX1TS
Xmips_mips_a_fullinstructionA_reg[11] instruction[11] 1017 clk__L1_N0
+ mips_mips_accfullinstruction[11] n9374 DFFTRX1TS
Xmips_mips_a_fullinstructionA_reg[12] instruction[12] 1018 clk__L1_N0
+ mips_mips_accfullinstruction[12] n9374 DFFTRX1TS
Xmips_mips_a_fullinstructionA_reg[13] instruction[13] 1019 clk__L1_N0
+ mips_mips_accfullinstruction[13] n9375 DFFTRX1TS
Xmips_mips_a_fullinstructionA_reg[14] instruction[14] 1020 clk__L1_N0
+ mips_mips_accfullinstruction[14] n9375 DFFTRX1TS
Xmips_mips_a_fullinstructionA_reg[15] instruction[15] 1021 clk__L1_N0
+ mips_mips_accfullinstruction[15] n9375 DFFTRX1TS
Xmips_mips_a_fullinstructionA_reg[16] instruction[16] 1022 clk__L1_N0
+ mips_mips_accfullinstruction[16] n9375 DFFTRX1TS
Xmips_mips_a_fullinstructionA_reg[17] instruction[17] 1023 clk__L1_N0
+ mips_mips_accfullinstruction[17] n9376 DFFTRX1TS
Xmips_mips_a_fullinstructionA_reg[18] instruction[18] 1024 clk__L1_N0
+ mips_mips_accfullinstruction[18] n9376 DFFTRX1TS
Xmips_mips_a_fullinstructionA_reg[19] instruction[19] 1025 clk__L1_N0
+ mips_mips_accfullinstruction[19] n9376 DFFTRX1TS
Xmips_mips_a_fullinstructionA_reg[20] instruction[20] 1026 clk__L1_N0
+ mips_mips_accfullinstruction[20] n9376 DFFTRX1TS
Xmips_mips_a_fullinstructionA_reg[21] instruction[21] 1027 clk__L1_N0
+ mips_mips_accfullinstruction[21] n9377 DFFTRX1TS
Xmips_mips_a_fullinstructionA_reg[22] instruction[22] 1028 clk__L1_N0
+ mips_mips_accfullinstruction[22] n9377 DFFTRX1TS
Xmips_mips_a_fullinstructionA_reg[23] instruction[23] 1029 clk__L1_N0
+ mips_mips_accfullinstruction[23] n9377 DFFTRX1TS
Xmips_mips_a_fullinstructionA_reg[24] instruction[24] 1030 clk__L1_N0
+ mips_mips_accfullinstruction[24] n9377 DFFTRX1TS
Xmips_mips_a_fullinstructionA_reg[25] instruction[25] 1031 clk__L1_N0
+ mips_mips_accfullinstruction[25] n9378 DFFTRX1TS
Xfifo_from_fir_fifo_cell14_hold_token_reg fifo_from_fir_hold[14] 1032
+ clk__L1_N0 fifo_from_fir_fifo_cell14_data_out_N9
+ fifo_from_fir_fifo_cell15_data_out_N35 DFFTRX1TS
Xfifo_from_fir_fifo_cell13_hold_token_reg fifo_from_fir_hold[13] 1033
+ clk__L1_N0 fifo_from_fir_fifo_cell13_data_out_N9
+ fifo_from_fir_fifo_cell14_data_out_N35 DFFTRX1TS
Xfifo_from_fir_fifo_cell12_hold_token_reg fifo_from_fir_hold[12] 1034
+ clk__L1_N0 fifo_from_fir_fifo_cell12_data_out_N9
+ fifo_from_fir_fifo_cell13_data_out_N35 DFFTRX1TS
Xfifo_from_fir_fifo_cell11_hold_token_reg fifo_from_fir_hold[11] 1035
+ clk__L1_N0 fifo_from_fir_fifo_cell11_data_out_N9
+ fifo_from_fir_fifo_cell12_data_out_N35 DFFTRX1TS
Xfifo_from_fir_fifo_cell10_hold_token_reg fifo_from_fir_hold[10] 1036
+ clk__L1_N0 fifo_from_fir_fifo_cell10_data_out_N9
+ fifo_from_fir_fifo_cell11_data_out_N35 DFFTRX1TS
Xfifo_from_fir_fifo_cell9_hold_token_reg fifo_from_fir_hold[9] 1037 clk__L1_N0
+ fifo_from_fir_fifo_cell9_data_out_N9 fifo_from_fir_fifo_cell10_data_out_N35
+ DFFTRX1TS
Xfifo_from_fir_fifo_cell8_hold_token_reg fifo_from_fir_hold[8] 1038 clk__L1_N0
+ fifo_from_fir_fifo_cell8_data_out_N9 fifo_from_fir_fifo_cell9_data_out_N35
+ DFFTRX1TS
Xfifo_from_fir_fifo_cell7_hold_token_reg fifo_from_fir_hold[7] 1039 clk__L1_N0
+ fifo_from_fir_fifo_cell7_data_out_N9 fifo_from_fir_fifo_cell8_data_out_N35
+ DFFTRX1TS
Xfifo_from_fir_fifo_cell6_hold_token_reg fifo_from_fir_hold[6] 1040 clk__L1_N0
+ fifo_from_fir_fifo_cell6_data_out_N9 fifo_from_fir_fifo_cell7_data_out_N35
+ DFFTRX1TS
Xfifo_from_fir_fifo_cell5_hold_token_reg fifo_from_fir_hold[5] 1041 clk__L1_N0
+ fifo_from_fir_fifo_cell5_data_out_N9 fifo_from_fir_fifo_cell6_data_out_N35
+ DFFTRX1TS
Xfifo_from_fir_fifo_cell4_hold_token_reg fifo_from_fir_hold[4] 1042 clk__L1_N0
+ fifo_from_fir_fifo_cell4_data_out_N9 fifo_from_fir_fifo_cell5_data_out_N35
+ DFFTRX1TS
Xfifo_from_fir_fifo_cell3_hold_token_reg fifo_from_fir_hold[3] 1043 clk__L1_N0
+ fifo_from_fir_fifo_cell3_data_out_N9 fifo_from_fir_fifo_cell4_data_out_N35
+ DFFTRX1TS
Xfifo_from_fir_fifo_cell2_hold_token_reg fifo_from_fir_hold[2] 1044 clk__L1_N0
+ fifo_from_fir_fifo_cell2_data_out_N9 fifo_from_fir_fifo_cell3_data_out_N35
+ DFFTRX1TS
Xfifo_from_fir_fifo_cell1_hold_token_reg fifo_from_fir_hold[1] 1045 clk__L1_N0
+ fifo_from_fir_fifo_cell1_data_out_N9 fifo_from_fir_fifo_cell2_data_out_N35
+ DFFTRX1TS
Xfifo_from_fir_fifo_cell0_hold_token_reg fifo_from_fir_hold[0] 1046 clk__L1_N0
+ fifo_from_fir_fifo_cell0_data_out_N9 fifo_from_fir_fifo_cell1_data_out_N35
+ DFFTRX1TS
Xfifo_from_fir_fifo_cell1_controller_write_enable_reg 1047
+ fifo_from_fir_fifo_cell1_controller_write_enable clk__L1_N0 n7598
+ fifo_from_fir_fifo_cell1_controller_valid_read n9542 EDFFTRX1TS
Xfifo_from_fir_fifo_cell2_controller_write_enable_reg 1048
+ fifo_from_fir_fifo_cell2_controller_write_enable clk__L1_N0 n7593
+ fifo_from_fir_fifo_cell2_controller_valid_read n9542 EDFFTRX1TS
Xfifo_from_fir_fifo_cell3_controller_write_enable_reg 1049
+ fifo_from_fir_fifo_cell3_controller_write_enable clk__L1_N0 n7588
+ fifo_from_fir_fifo_cell3_controller_valid_read n9543 EDFFTRX1TS
Xfifo_from_fir_fifo_cell4_controller_write_enable_reg 1050
+ fifo_from_fir_fifo_cell4_controller_write_enable clk__L1_N0 n7583
+ fifo_from_fir_fifo_cell4_controller_valid_read n9545 EDFFTRX1TS
Xfifo_from_fir_fifo_cell5_controller_write_enable_reg 1051
+ fifo_from_fir_fifo_cell5_controller_write_enable clk__L1_N0 n7578
+ fifo_from_fir_fifo_cell5_controller_valid_read n9543 EDFFTRX1TS
Xfifo_from_fir_fifo_cell6_controller_write_enable_reg 1052
+ fifo_from_fir_fifo_cell6_controller_write_enable clk__L1_N0 n7573
+ fifo_from_fir_fifo_cell6_controller_valid_read n9545 EDFFTRX1TS
Xfifo_from_fir_fifo_cell7_controller_write_enable_reg 1053
+ fifo_from_fir_fifo_cell7_controller_write_enable clk__L1_N0 n7568
+ fifo_from_fir_fifo_cell7_controller_valid_read n9544 EDFFTRX1TS
Xfifo_from_fir_fifo_cell8_controller_write_enable_reg 1054
+ fifo_from_fir_fifo_cell8_controller_write_enable clk__L1_N0 n7563
+ fifo_from_fir_fifo_cell8_controller_valid_read n9544 EDFFTRX1TS
Xfifo_from_fir_fifo_cell9_controller_write_enable_reg 1055
+ fifo_from_fir_fifo_cell9_controller_write_enable clk__L1_N0 n7558
+ fifo_from_fir_fifo_cell9_controller_valid_read n9544 EDFFTRX1TS
Xfifo_from_fir_fifo_cell10_controller_write_enable_reg 1056
+ fifo_from_fir_fifo_cell10_controller_write_enable clk__L1_N0 n7553
+ fifo_from_fir_fifo_cell10_controller_valid_read n9543 EDFFTRX1TS
Xfifo_from_fir_fifo_cell11_controller_write_enable_reg 1057
+ fifo_from_fir_fifo_cell11_controller_write_enable clk__L1_N0 n7548
+ fifo_from_fir_fifo_cell11_controller_valid_read n9543 EDFFTRX1TS
Xfifo_from_fir_fifo_cell12_controller_write_enable_reg 1058
+ fifo_from_fir_fifo_cell12_controller_write_enable clk__L1_N0 n7543
+ fifo_from_fir_fifo_cell12_controller_valid_read n7618 EDFFTRX1TS
Xfifo_from_fir_fifo_cell13_controller_write_enable_reg 1059
+ fifo_from_fir_fifo_cell13_controller_write_enable clk__L1_N0 n7538
+ fifo_from_fir_fifo_cell13_controller_valid_read n9547 EDFFTRX1TS
Xfifo_from_fir_fifo_cell14_controller_write_enable_reg 1060
+ fifo_from_fir_fifo_cell14_controller_write_enable clk__L1_N0 n7533
+ fifo_from_fir_fifo_cell14_controller_valid_read n9538 EDFFTRX1TS
Xfifo_from_fir_fifo_cell15_controller_write_enable_reg 1061
+ fifo_from_fir_fifo_cell15_controller_write_enable clk__L1_N0 n7528
+ fifo_from_fir_fifo_cell15_controller_valid_read n9539 EDFFTRX1TS
Xrouter_addr_calc_fir_read_calc_counter_count_reg[0]
+ router_addr_calc_fir_read_calc_count[0] n7955 clk__L1_N0
+ router_addr_calc_fir_read_calc_counter_N178 FE_OFN1190_n7022 EDFFX1TS
Xrouter_addr_calc_fir_write_calc_counter_count_reg[0]
+ router_addr_calc_fir_write_calc_count[0] n7956 clk__L1_N0
+ router_addr_calc_fir_write_calc_counter_N178 FE_OFN1179_n7020 EDFFX1TS
Xrouter_addr_calc_fft_read_calc_counter_count_reg[0]
+ router_addr_calc_fft_read_calc_count[0] n7957 clk__L1_N0
+ router_addr_calc_fft_read_calc_counter_N178 FE_OFN1169_n7021 EDFFX1TS
Xrouter_addr_calc_fft_write_calc_counter_count_reg[0]
+ router_addr_calc_fft_write_calc_count[0] n7958 clk__L1_N0
+ router_addr_calc_fft_write_calc_counter_N178 FE_OFN1161_n7019 EDFFX1TS
Xfifo_to_fft_fifo_cell0_controller_write_enable_reg 1062
+ fifo_to_fft_fifo_cell0_controller_write_enable clk__L1_N0 n7231
+ fifo_to_fft_fifo_cell0_controller_valid_read n9537 EDFFTRX1TS
Xfifo_to_fft_fifo_cell15_data_out_en_reg fifo_to_fft_fifo_cell15_control_signal
+ 1063 clk__L1_N0 fifo_to_fft_fifo_cell14_reg_gtok_token n3959 DFFTRX1TS
Xfifo_to_fft_fifo_cell15_controller_write_enable_reg 1064
+ fifo_to_fft_fifo_cell15_controller_write_enable clk__L1_N0 n7241
+ fifo_to_fft_fifo_cell15_controller_valid_read n9538 EDFFTRX1TS
Xfifo_to_fft_fifo_cell14_data_out_en_reg 1065 n2891 clk__L1_N0
+ fifo_to_fft_fifo_cell13_reg_gtok_token FE_OFN699_n3959 DFFTRX1TS
Xfifo_to_fft_fifo_cell14_hold_token_reg fifo_to_fft_hold[14] 1066 clk__L1_N0
+ n2891 fifo_to_fft_fifo_cell15_data_out_N35 DFFTRX1TS
Xfifo_to_fft_fifo_cell14_controller_write_enable_reg 1067
+ fifo_to_fft_fifo_cell14_controller_write_enable clk__L1_N0 n7246
+ fifo_to_fft_fifo_cell14_controller_valid_read n9537 EDFFTRX1TS
Xfifo_to_fft_fifo_cell13_data_out_en_reg 1068 n2888 clk__L1_N0
+ fifo_to_fft_fifo_cell12_reg_gtok_token FE_OFN703_n3959 DFFTRX1TS
Xfifo_to_fft_fifo_cell13_hold_token_reg fifo_to_fft_hold[13] 1069 clk__L1_N0
+ n2888 fifo_to_fft_fifo_cell14_data_out_N35 DFFTRX1TS
Xfifo_to_fft_fifo_cell13_controller_write_enable_reg 1070
+ fifo_to_fft_fifo_cell13_controller_write_enable clk__L1_N0 n7251
+ fifo_to_fft_fifo_cell13_controller_valid_read n9536 EDFFTRX1TS
Xfifo_to_fft_fifo_cell12_data_out_en_reg 1071 n2885 clk__L1_N0
+ fifo_to_fft_fifo_cell11_reg_gtok_token FE_OFN707_n3959 DFFTRX1TS
Xfifo_to_fft_fifo_cell12_hold_token_reg fifo_to_fft_hold[12] 1072 clk__L1_N0
+ n2885 fifo_to_fft_fifo_cell13_data_out_N35 DFFTRX1TS
Xfifo_to_fft_fifo_cell12_controller_write_enable_reg 1073
+ fifo_to_fft_fifo_cell12_controller_write_enable clk__L1_N0 n7260
+ fifo_to_fft_fifo_cell12_controller_valid_read n7618 EDFFTRX1TS
Xfifo_to_fft_fifo_cell11_data_out_en_reg 1074 n2882 clk__L1_N0
+ fifo_to_fft_fifo_cell10_reg_gtok_token FE_OFN707_n3959 DFFTRX1TS
Xfifo_to_fft_fifo_cell11_hold_token_reg fifo_to_fft_hold[11] 1075 clk__L1_N0
+ n2882 fifo_to_fft_fifo_cell12_data_out_N35 DFFTRX1TS
Xfifo_to_fft_fifo_cell11_controller_write_enable_reg 1076
+ fifo_to_fft_fifo_cell11_controller_write_enable clk__L1_N0 n7270
+ fifo_to_fft_fifo_cell11_controller_valid_read n9532 EDFFTRX1TS
Xfifo_to_fft_fifo_cell10_data_out_en_reg 1077 n2879 clk__L1_N0
+ fifo_to_fft_fifo_cell9_reg_gtok_token FE_OFN706_n3959 DFFTRX1TS
Xfifo_to_fft_fifo_cell10_hold_token_reg fifo_to_fft_hold[10] 1078 clk__L1_N0
+ n2879 fifo_to_fft_fifo_cell11_data_out_N35 DFFTRX1TS
Xfifo_to_fft_fifo_cell10_controller_write_enable_reg 1079
+ fifo_to_fft_fifo_cell10_controller_write_enable clk__L1_N0 n7275
+ fifo_to_fft_fifo_cell10_controller_valid_read n9532 EDFFTRX1TS
Xfifo_to_fft_fifo_cell9_data_out_en_reg 1080 n2876 clk__L1_N0
+ fifo_to_fft_fifo_cell8_reg_gtok_token FE_OFN706_n3959 DFFTRX1TS
Xfifo_to_fft_fifo_cell9_hold_token_reg fifo_to_fft_hold[9] 1081 clk__L1_N0
+ n2876 fifo_to_fft_fifo_cell10_data_out_N35 DFFTRX1TS
Xfifo_to_fft_fifo_cell9_controller_write_enable_reg 1082
+ fifo_to_fft_fifo_cell9_controller_write_enable clk__L1_N0 n7280
+ fifo_to_fft_fifo_cell9_controller_valid_read n9533 EDFFTRX1TS
Xfifo_to_fft_fifo_cell8_data_out_en_reg 1083 n2873 clk__L1_N0
+ fifo_to_fft_fifo_cell7_reg_gtok_token FE_OFN705_n3959 DFFTRX1TS
Xfifo_to_fft_fifo_cell8_hold_token_reg fifo_to_fft_hold[8] 1084 clk__L1_N0
+ n2873 fifo_to_fft_fifo_cell9_data_out_N35 DFFTRX1TS
Xfifo_to_fft_fifo_cell8_controller_write_enable_reg 1085
+ fifo_to_fft_fifo_cell8_controller_write_enable clk__L1_N0 n7290
+ fifo_to_fft_fifo_cell8_controller_valid_read n9531 EDFFTRX1TS
Xfifo_to_fft_fifo_cell7_data_out_en_reg 1086 n2870 clk__L1_N0
+ fifo_to_fft_fifo_cell6_reg_gtok_token FE_OFN708_n3959 DFFTRX1TS
Xfifo_to_fft_fifo_cell7_hold_token_reg fifo_to_fft_hold[7] 1087 clk__L1_N0
+ n2870 fifo_to_fft_fifo_cell8_data_out_N35 DFFTRX1TS
Xfifo_to_fft_fifo_cell7_controller_write_enable_reg 1088
+ fifo_to_fft_fifo_cell7_controller_write_enable clk__L1_N0 n7300
+ fifo_to_fft_fifo_cell7_controller_valid_read n9536 EDFFTRX1TS
Xfifo_to_fft_fifo_cell6_data_out_en_reg 1089 n2867 clk__L1_N0
+ fifo_to_fft_fifo_cell5_reg_gtok_token FE_OFN708_n3959 DFFTRX1TS
Xfifo_to_fft_fifo_cell6_hold_token_reg fifo_to_fft_hold[6] 1090 clk__L1_N0
+ n2867 fifo_to_fft_fifo_cell7_data_out_N35 DFFTRX1TS
Xfifo_to_fft_fifo_cell6_controller_write_enable_reg 1091
+ fifo_to_fft_fifo_cell6_controller_write_enable clk__L1_N0 n7305
+ fifo_to_fft_fifo_cell6_controller_valid_read n9532 EDFFTRX1TS
Xfifo_to_fft_fifo_cell5_data_out_en_reg 1092 n2864 clk__L1_N0
+ fifo_to_fft_fifo_cell4_reg_gtok_token FE_OFN708_n3959 DFFTRX1TS
Xfifo_to_fft_fifo_cell5_hold_token_reg fifo_to_fft_hold[5] 1093 clk__L1_N0
+ n2864 fifo_to_fft_fifo_cell6_data_out_N35 DFFTRX1TS
Xfifo_to_fft_fifo_cell5_controller_write_enable_reg 1094
+ fifo_to_fft_fifo_cell5_controller_write_enable clk__L1_N0 n7310
+ fifo_to_fft_fifo_cell5_controller_valid_read n9534 EDFFTRX1TS
Xfifo_to_fft_fifo_cell4_data_out_en_reg 1095 n2861 clk__L1_N0
+ fifo_to_fft_fifo_cell3_reg_gtok_token FE_OFN704_n3959 DFFTRX1TS
Xfifo_to_fft_fifo_cell4_hold_token_reg fifo_to_fft_hold[4] 1096 clk__L1_N0
+ n2861 fifo_to_fft_fifo_cell5_data_out_N35 DFFTRX1TS
Xfifo_to_fft_fifo_cell4_controller_write_enable_reg 1097
+ fifo_to_fft_fifo_cell4_controller_write_enable clk__L1_N0 n7320
+ fifo_to_fft_fifo_cell4_controller_valid_read n9532 EDFFTRX1TS
Xfifo_to_fft_fifo_cell3_data_out_en_reg 1098 n2858 clk__L1_N0
+ fifo_to_fft_fifo_cell2_reg_gtok_token FE_OFN704_n3959 DFFTRX1TS
Xfifo_to_fft_fifo_cell3_hold_token_reg fifo_to_fft_hold[3] 1099 clk__L1_N0
+ n2858 fifo_to_fft_fifo_cell4_data_out_N35 DFFTRX1TS
Xfifo_to_fft_fifo_cell3_controller_write_enable_reg 1100
+ fifo_to_fft_fifo_cell3_controller_write_enable clk__L1_N0 n7325
+ fifo_to_fft_fifo_cell3_controller_valid_read n9536 EDFFTRX1TS
Xfifo_to_fft_fifo_cell2_data_out_en_reg 1101 n2855 clk__L1_N0
+ fifo_to_fft_fifo_cell1_reg_gtok_token FE_OFN701_n3959 DFFTRX1TS
Xfifo_to_fft_fifo_cell2_hold_token_reg fifo_to_fft_hold[2] 1102 clk__L1_N0
+ n2855 fifo_to_fft_fifo_cell3_data_out_N35 DFFTRX1TS
Xfifo_to_fft_fifo_cell2_controller_write_enable_reg 1103
+ fifo_to_fft_fifo_cell2_controller_write_enable clk__L1_N0 n7330
+ fifo_to_fft_fifo_cell2_controller_valid_read n9535 EDFFTRX1TS
Xfifo_to_fft_fifo_cell1_data_out_en_reg 1104 n2852 clk__L1_N0
+ fifo_to_fft_fifo_cell0_reg_gtok_token FE_OFN700_n3959 DFFTRX1TS
Xfifo_to_fft_fifo_cell1_hold_token_reg fifo_to_fft_hold[1] 1105 clk__L1_N0
+ n2852 fifo_to_fft_fifo_cell2_data_out_N35 DFFTRX1TS
Xfifo_to_fft_fifo_cell1_controller_write_enable_reg 1106
+ fifo_to_fft_fifo_cell1_controller_write_enable clk__L1_N0 n7340
+ fifo_to_fft_fifo_cell1_controller_valid_read n9546 EDFFTRX1TS
Xrouter_data_cntl_fir_full_flag_reg router_data_cntl_fir_full_flag n3470
+ clk__L1_N0 FE_OFN1285_router_ram_read_enable_reg n8095 EDFFX1TS
Xfifo_to_fir_fifo_cell0_controller_write_enable_reg 1107
+ fifo_to_fir_fifo_cell0_controller_write_enable clk__L1_N0 n7226
+ fifo_to_fir_fifo_cell0_controller_valid_read n9533 EDFFTRX1TS
Xfifo_to_fir_fifo_cell15_data_out_en_reg fifo_to_fir_fifo_cell15_control_signal
+ 1108 clk__L1_N0 fifo_to_fir_fifo_cell14_reg_gtok_token FE_OFN684_n4134
+ DFFTRX1TS
Xfifo_to_fir_fifo_cell15_controller_write_enable_reg 1109
+ fifo_to_fir_fifo_cell15_controller_write_enable clk__L1_N0 n7350
+ fifo_to_fir_fifo_cell15_controller_valid_read n9533 EDFFTRX1TS
Xfifo_to_fir_fifo_cell14_data_out_en_reg 1110 n2843 clk__L1_N0
+ fifo_to_fir_fifo_cell13_reg_gtok_token FE_OFN695_n4134 DFFTRX1TS
Xfifo_to_fir_fifo_cell14_hold_token_reg fifo_to_fir_hold[14] 1111 clk__L1_N0
+ n2843 fifo_to_fir_fifo_cell15_data_out_N35 DFFTRX1TS
Xfifo_to_fir_fifo_cell14_controller_write_enable_reg 1112
+ fifo_to_fir_fifo_cell14_controller_write_enable clk__L1_N0 n7355
+ fifo_to_fir_fifo_cell14_controller_valid_read n9535 EDFFTRX1TS
Xfifo_to_fir_fifo_cell13_data_out_en_reg 1113 n2840 clk__L1_N0
+ fifo_to_fir_fifo_cell12_reg_gtok_token FE_OFN695_n4134 DFFTRX1TS
Xfifo_to_fir_fifo_cell13_hold_token_reg fifo_to_fir_hold[13] 1114 clk__L1_N0
+ n2840 fifo_to_fir_fifo_cell14_data_out_N35 DFFTRX1TS
Xfifo_to_fir_fifo_cell13_controller_write_enable_reg 1115
+ fifo_to_fir_fifo_cell13_controller_write_enable clk__L1_N0 n7360
+ fifo_to_fir_fifo_cell13_controller_valid_read n9533 EDFFTRX1TS
Xfifo_to_fir_fifo_cell12_data_out_en_reg 1116 n2837 clk__L1_N0
+ fifo_to_fir_fifo_cell11_reg_gtok_token FE_OFN694_n4134 DFFTRX1TS
Xfifo_to_fir_fifo_cell12_hold_token_reg fifo_to_fir_hold[12] 1117 clk__L1_N0
+ n2837 fifo_to_fir_fifo_cell13_data_out_N35 DFFTRX1TS
Xfifo_to_fir_fifo_cell12_controller_write_enable_reg 1118
+ fifo_to_fir_fifo_cell12_controller_write_enable clk__L1_N0 n7369
+ fifo_to_fir_fifo_cell12_controller_valid_read n9534 EDFFTRX1TS
Xfifo_to_fir_fifo_cell11_data_out_en_reg 1119 n2834 clk__L1_N0
+ fifo_to_fir_fifo_cell10_reg_gtok_token FE_OFN693_n4134 DFFTRX1TS
Xfifo_to_fir_fifo_cell11_hold_token_reg fifo_to_fir_hold[11] 1120 clk__L1_N0
+ n2834 fifo_to_fir_fifo_cell12_data_out_N35 DFFTRX1TS
Xfifo_to_fir_fifo_cell11_controller_write_enable_reg 1121
+ fifo_to_fir_fifo_cell11_controller_write_enable clk__L1_N0 n7379
+ fifo_to_fir_fifo_cell11_controller_valid_read n9537 EDFFTRX1TS
Xfifo_to_fir_fifo_cell10_data_out_en_reg 1122 n2831 clk__L1_N0
+ fifo_to_fir_fifo_cell9_reg_gtok_token FE_OFN693_n4134 DFFTRX1TS
Xfifo_to_fir_fifo_cell10_hold_token_reg fifo_to_fir_hold[10] 1123 clk__L1_N0
+ n2831 fifo_to_fir_fifo_cell11_data_out_N35 DFFTRX1TS
Xfifo_to_fir_fifo_cell10_controller_write_enable_reg 1124
+ fifo_to_fir_fifo_cell10_controller_write_enable clk__L1_N0 n7384
+ fifo_to_fir_fifo_cell10_controller_valid_read n9534 EDFFTRX1TS
Xfifo_to_fir_fifo_cell9_data_out_en_reg 1125 n2828 clk__L1_N0
+ fifo_to_fir_fifo_cell8_reg_gtok_token FE_OFN691_n4134 DFFTRX1TS
Xfifo_to_fir_fifo_cell9_hold_token_reg fifo_to_fir_hold[9] 1126 clk__L1_N0
+ n2828 fifo_to_fir_fifo_cell10_data_out_N35 DFFTRX1TS
Xfifo_to_fir_fifo_cell9_controller_write_enable_reg 1127
+ fifo_to_fir_fifo_cell9_controller_write_enable clk__L1_N0 n7389
+ fifo_to_fir_fifo_cell9_controller_valid_read n9534 EDFFTRX1TS
Xfifo_to_fir_fifo_cell8_data_out_en_reg 1128 n2825 clk__L1_N0
+ fifo_to_fir_fifo_cell7_reg_gtok_token FE_OFN689_n4134 DFFTRX1TS
Xfifo_to_fir_fifo_cell8_hold_token_reg fifo_to_fir_hold[8] 1129 clk__L1_N0
+ n2825 fifo_to_fir_fifo_cell9_data_out_N35 DFFTRX1TS
Xfifo_to_fir_fifo_cell8_controller_write_enable_reg 1130
+ fifo_to_fir_fifo_cell8_controller_write_enable clk__L1_N0 n7399
+ fifo_to_fir_fifo_cell8_controller_valid_read n9537 EDFFTRX1TS
Xfifo_to_fir_fifo_cell7_data_out_en_reg 1131 n2822 clk__L1_N0
+ fifo_to_fir_fifo_cell6_reg_gtok_token FE_OFN689_n4134 DFFTRX1TS
Xfifo_to_fir_fifo_cell7_hold_token_reg fifo_to_fir_hold[7] 1132 clk__L1_N0
+ n2822 fifo_to_fir_fifo_cell8_data_out_N35 DFFTRX1TS
Xfifo_to_fir_fifo_cell7_controller_write_enable_reg 1133
+ fifo_to_fir_fifo_cell7_controller_write_enable clk__L1_N0 n7409
+ fifo_to_fir_fifo_cell7_controller_valid_read n9535 EDFFTRX1TS
Xfifo_to_fir_fifo_cell6_data_out_en_reg 1134 n2819 clk__L1_N0
+ fifo_to_fir_fifo_cell5_reg_gtok_token FE_OFN688_n4134 DFFTRX1TS
Xfifo_to_fir_fifo_cell6_hold_token_reg fifo_to_fir_hold[6] 1135 clk__L1_N0
+ n2819 fifo_to_fir_fifo_cell7_data_out_N35 DFFTRX1TS
Xfifo_to_fir_fifo_cell6_controller_write_enable_reg 1136
+ fifo_to_fir_fifo_cell6_controller_write_enable clk__L1_N0 n7414
+ fifo_to_fir_fifo_cell6_controller_valid_read n9535 EDFFTRX1TS
Xfifo_to_fir_fifo_cell5_data_out_en_reg 1137 n2816 clk__L1_N0
+ fifo_to_fir_fifo_cell4_reg_gtok_token FE_OFN685_n4134 DFFTRX1TS
Xfifo_to_fir_fifo_cell5_hold_token_reg fifo_to_fir_hold[5] 1138 clk__L1_N0
+ n2816 fifo_to_fir_fifo_cell6_data_out_N35 DFFTRX1TS
Xfifo_to_fir_fifo_cell5_controller_write_enable_reg 1139
+ fifo_to_fir_fifo_cell5_controller_write_enable clk__L1_N0 n7419
+ fifo_to_fir_fifo_cell5_controller_valid_read n7618 EDFFTRX1TS
Xfifo_to_fir_fifo_cell4_data_out_en_reg 1140 n2813 clk__L1_N0
+ fifo_to_fir_fifo_cell3_reg_gtok_token FE_OFN686_n4134 DFFTRX1TS
Xfifo_to_fir_fifo_cell4_hold_token_reg fifo_to_fir_hold[4] 1141 clk__L1_N0
+ n2813 fifo_to_fir_fifo_cell5_data_out_N35 DFFTRX1TS
Xfifo_to_fir_fifo_cell4_controller_write_enable_reg 1142
+ fifo_to_fir_fifo_cell4_controller_write_enable clk__L1_N0 n7429
+ fifo_to_fir_fifo_cell4_controller_valid_read n9539 EDFFTRX1TS
Xfifo_to_fir_fifo_cell3_data_out_en_reg 1143 n2810 clk__L1_N0
+ fifo_to_fir_fifo_cell2_reg_gtok_token FE_OFN685_n4134 DFFTRX1TS
Xfifo_to_fir_fifo_cell3_hold_token_reg fifo_to_fir_hold[3] 1144 clk__L1_N0
+ n2810 fifo_to_fir_fifo_cell4_data_out_N35 DFFTRX1TS
Xfifo_to_fir_fifo_cell3_controller_write_enable_reg 1145
+ fifo_to_fir_fifo_cell3_controller_write_enable clk__L1_N0 n7434
+ fifo_to_fir_fifo_cell3_controller_valid_read n9536 EDFFTRX1TS
Xfifo_to_fir_fifo_cell2_data_out_en_reg 1146 n2807 clk__L1_N0
+ fifo_to_fir_fifo_cell1_reg_gtok_token FE_OFN684_n4134 DFFTRX1TS
Xfifo_to_fir_fifo_cell2_hold_token_reg fifo_to_fir_hold[2] 1147 clk__L1_N0
+ n2807 fifo_to_fir_fifo_cell3_data_out_N35 DFFTRX1TS
Xfifo_to_fir_fifo_cell2_controller_write_enable_reg 1148
+ fifo_to_fir_fifo_cell2_controller_write_enable clk__L1_N0 n7439
+ fifo_to_fir_fifo_cell2_controller_valid_read n9538 EDFFTRX1TS
Xfifo_to_fir_fifo_cell1_data_out_en_reg 1149 n2804 clk__L1_N0
+ fifo_to_fir_fifo_cell0_reg_gtok_token FE_OFN683_n4134 DFFTRX1TS
Xfifo_to_fir_fifo_cell1_hold_token_reg fifo_to_fir_hold[1] 1150 clk__L1_N0
+ n2804 fifo_to_fir_fifo_cell2_data_out_N35 DFFTRX1TS
Xfifo_to_fir_fifo_cell1_controller_write_enable_reg 1151
+ fifo_to_fir_fifo_cell1_controller_write_enable clk__L1_N0 n7449
+ fifo_to_fir_fifo_cell1_controller_valid_read n9538 EDFFTRX1TS
Xfifo_from_fft_fifo_cell14_hold_token_reg fifo_from_fft_hold[14] 1152
+ clk__L1_N0 fifo_from_fft_fifo_cell14_data_out_N9
+ fifo_from_fft_fifo_cell15_data_out_N35 DFFTRX1TS
Xfifo_from_fft_fifo_cell13_hold_token_reg fifo_from_fft_hold[13] 1153
+ clk__L1_N0 fifo_from_fft_fifo_cell13_data_out_N9
+ fifo_from_fft_fifo_cell14_data_out_N35 DFFTRX1TS
Xfifo_from_fft_fifo_cell12_hold_token_reg fifo_from_fft_hold[12] 1154
+ clk__L1_N0 fifo_from_fft_fifo_cell12_data_out_N9
+ fifo_from_fft_fifo_cell13_data_out_N35 DFFTRX1TS
Xfifo_from_fft_fifo_cell11_hold_token_reg fifo_from_fft_hold[11] 1155
+ clk__L1_N0 fifo_from_fft_fifo_cell11_data_out_N9
+ fifo_from_fft_fifo_cell12_data_out_N35 DFFTRX1TS
Xfifo_from_fft_fifo_cell10_hold_token_reg fifo_from_fft_hold[10] 1156
+ clk__L1_N0 fifo_from_fft_fifo_cell10_data_out_N9
+ fifo_from_fft_fifo_cell11_data_out_N35 DFFTRX1TS
Xfifo_from_fft_fifo_cell9_hold_token_reg fifo_from_fft_hold[9] 1157 clk__L1_N0
+ fifo_from_fft_fifo_cell9_data_out_N9 fifo_from_fft_fifo_cell10_data_out_N35
+ DFFTRX1TS
Xfifo_from_fft_fifo_cell8_hold_token_reg fifo_from_fft_hold[8] 1158 clk__L1_N0
+ fifo_from_fft_fifo_cell8_data_out_N9 fifo_from_fft_fifo_cell9_data_out_N35
+ DFFTRX1TS
Xfifo_from_fft_fifo_cell7_hold_token_reg fifo_from_fft_hold[7] 1159 clk__L1_N0
+ fifo_from_fft_fifo_cell7_data_out_N9 fifo_from_fft_fifo_cell8_data_out_N35
+ DFFTRX1TS
Xfifo_from_fft_fifo_cell6_hold_token_reg fifo_from_fft_hold[6] 1160 clk__L1_N0
+ fifo_from_fft_fifo_cell6_data_out_N9 fifo_from_fft_fifo_cell7_data_out_N35
+ DFFTRX1TS
Xfifo_from_fft_fifo_cell5_hold_token_reg fifo_from_fft_hold[5] 1161 clk__L1_N0
+ fifo_from_fft_fifo_cell5_data_out_N9 fifo_from_fft_fifo_cell6_data_out_N35
+ DFFTRX1TS
Xfifo_from_fft_fifo_cell4_hold_token_reg fifo_from_fft_hold[4] 1162 clk__L1_N0
+ fifo_from_fft_fifo_cell4_data_out_N9 fifo_from_fft_fifo_cell5_data_out_N35
+ DFFTRX1TS
Xfifo_from_fft_fifo_cell3_hold_token_reg fifo_from_fft_hold[3] 1163 clk__L1_N0
+ fifo_from_fft_fifo_cell3_data_out_N9 fifo_from_fft_fifo_cell4_data_out_N35
+ DFFTRX1TS
Xfifo_from_fft_fifo_cell2_hold_token_reg fifo_from_fft_hold[2] 1164 clk__L1_N0
+ fifo_from_fft_fifo_cell2_data_out_N9 fifo_from_fft_fifo_cell3_data_out_N35
+ DFFTRX1TS
Xfifo_from_fft_fifo_cell1_hold_token_reg fifo_from_fft_hold[1] 1165 clk__L1_N0
+ fifo_from_fft_fifo_cell1_data_out_N9 fifo_from_fft_fifo_cell2_data_out_N35
+ DFFTRX1TS
Xfifo_from_fft_fifo_cell0_hold_token_reg fifo_from_fft_hold[0] 1166 clk__L1_N0
+ fifo_from_fft_fifo_cell0_data_out_N9 fifo_from_fft_fifo_cell1_data_out_N35
+ DFFTRX1TS
Xfifo_from_fft_fifo_cell1_controller_write_enable_reg 1167
+ fifo_from_fft_fifo_cell1_controller_write_enable clk__L1_N0 n7523
+ fifo_from_fft_fifo_cell1_controller_valid_read n9539 EDFFTRX1TS
Xfifo_from_fft_fifo_cell2_controller_write_enable_reg 1168
+ fifo_from_fft_fifo_cell2_controller_write_enable clk__L1_N0 n7518
+ fifo_from_fft_fifo_cell2_controller_valid_read n9539 EDFFTRX1TS
Xfifo_from_fft_fifo_cell3_controller_write_enable_reg 1169
+ fifo_from_fft_fifo_cell3_controller_write_enable clk__L1_N0 n7513
+ fifo_from_fft_fifo_cell3_controller_valid_read n9540 EDFFTRX1TS
Xfifo_from_fft_fifo_cell4_controller_write_enable_reg 1170
+ fifo_from_fft_fifo_cell4_controller_write_enable clk__L1_N0 n7508
+ fifo_from_fft_fifo_cell4_controller_valid_read n9540 EDFFTRX1TS
Xfifo_from_fft_fifo_cell5_controller_write_enable_reg 1171
+ fifo_from_fft_fifo_cell5_controller_write_enable clk__L1_N0 n7503
+ fifo_from_fft_fifo_cell5_controller_valid_read n9540 EDFFTRX1TS
Xfifo_from_fft_fifo_cell6_controller_write_enable_reg 1172
+ fifo_from_fft_fifo_cell6_controller_write_enable clk__L1_N0 n7498
+ fifo_from_fft_fifo_cell6_controller_valid_read n9540 EDFFTRX1TS
Xfifo_from_fft_fifo_cell7_controller_write_enable_reg 1173
+ fifo_from_fft_fifo_cell7_controller_write_enable clk__L1_N0 n7493
+ fifo_from_fft_fifo_cell7_controller_valid_read n9541 EDFFTRX1TS
Xfifo_from_fft_fifo_cell8_controller_write_enable_reg 1174
+ fifo_from_fft_fifo_cell8_controller_write_enable clk__L1_N0 n7489
+ fifo_from_fft_fifo_cell8_controller_valid_read n9541 EDFFTRX1TS
Xfifo_from_fft_fifo_cell9_controller_write_enable_reg 1175
+ fifo_from_fft_fifo_cell9_controller_write_enable clk__L1_N0 n7484
+ fifo_from_fft_fifo_cell9_controller_valid_read n9541 EDFFTRX1TS
Xfifo_from_fft_fifo_cell10_controller_write_enable_reg 1176
+ fifo_from_fft_fifo_cell10_controller_write_enable clk__L1_N0 n7479
+ fifo_from_fft_fifo_cell10_controller_valid_read n9541 EDFFTRX1TS
Xfifo_from_fft_fifo_cell11_controller_write_enable_reg 1177
+ fifo_from_fft_fifo_cell11_controller_write_enable clk__L1_N0 n7474
+ fifo_from_fft_fifo_cell11_controller_valid_read n9542 EDFFTRX1TS
Xfifo_from_fft_fifo_cell12_controller_write_enable_reg 1178
+ fifo_from_fft_fifo_cell12_controller_write_enable clk__L1_N0 n7469
+ fifo_from_fft_fifo_cell12_controller_valid_read n9542 EDFFTRX1TS
Xfifo_from_fft_fifo_cell13_controller_write_enable_reg 1179
+ fifo_from_fft_fifo_cell13_controller_write_enable clk__L1_N0 n7464
+ fifo_from_fft_fifo_cell13_controller_valid_read n9544 EDFFTRX1TS
Xfifo_from_fft_fifo_cell14_controller_write_enable_reg 1180
+ fifo_from_fft_fifo_cell14_controller_write_enable clk__L1_N0 n7459
+ fifo_from_fft_fifo_cell14_controller_valid_read n9545 EDFFTRX1TS
Xfifo_from_fft_fifo_cell15_controller_write_enable_reg 1181
+ fifo_from_fft_fifo_cell15_controller_write_enable clk__L1_N0 n7454
+ fifo_from_fft_fifo_cell15_controller_valid_read n9545 EDFFTRX1TS
Xrouter_addr_calc_iir_write_calc_counter_count_reg[0]
+ router_addr_calc_iir_write_calc_count[0] n7959 clk__L1_N0
+ router_addr_calc_iir_write_calc_counter_N178
+ FE_OFN1207_router_addr_calc_iir_write_calc_counter_N212 EDFFX1TS
Xrouter_addr_calc_iir_write_calc_counter_count_reg[16]
+ router_addr_calc_iir_write_calc_count[16] 1182 clk__L1_N0
+ router_addr_calc_iir_write_calc_counter_N194
+ FE_OFN1205_router_addr_calc_iir_write_calc_counter_N212 EDFFX1TS
Xrouter_addr_calc_iir_write_calc_counter_count_reg[19]
+ router_addr_calc_iir_write_calc_count[19] 1183 clk__L1_N0
+ router_addr_calc_iir_write_calc_counter_N197
+ FE_OFN1202_router_addr_calc_iir_write_calc_counter_N212 EDFFX1TS
Xrouter_addr_calc_iir_write_calc_counter_count_reg[27]
+ router_addr_calc_iir_write_calc_count[27] 1184 clk__L1_N0
+ router_addr_calc_iir_write_calc_counter_N205
+ FE_OFN1199_router_addr_calc_iir_write_calc_counter_N212 EDFFX1TS
Xrouter_addr_calc_iir_write_calc_counter_count_reg[30]
+ router_addr_calc_iir_write_calc_count[30] n7952 clk__L1_N0
+ router_addr_calc_iir_write_calc_counter_N208 n7014 EDFFX1TS
XU218 router_data_cntl_N138 n3468 n3469 NAND2X1TS
XU233 router_addr_calc_iir_write_calc_counter_N208 FE_OFN1293_iir_enable n3488
+ NAND2X1TS
XU235 router_addr_calc_iir_write_calc_counter_N207 FE_OFN1295_iir_enable n3489
+ NAND2X1TS
XU237 router_addr_calc_iir_write_calc_counter_N206 FE_OFN1296_iir_enable n3490
+ NAND2X1TS
XU239 router_addr_calc_iir_write_calc_counter_N205 FE_OFN1296_iir_enable n3491
+ NAND2X1TS
XU241 router_addr_calc_iir_write_calc_counter_N204 FE_OFN1296_iir_enable n3492
+ NAND2X1TS
XU243 router_addr_calc_iir_write_calc_counter_N203 FE_OFN1293_iir_enable n3493
+ NAND2X1TS
XU245 router_addr_calc_iir_write_calc_counter_N202 FE_OFN1291_iir_enable n3494
+ NAND2X1TS
XU247 router_addr_calc_iir_write_calc_counter_N201 FE_OFN1291_iir_enable n3495
+ NAND2X1TS
XU249 router_addr_calc_iir_write_calc_counter_N200 FE_OFN1288_iir_enable n3496
+ NAND2X1TS
XU251 router_addr_calc_iir_write_calc_counter_N199 FE_OFN1290_iir_enable n3497
+ NAND2X1TS
XU253 router_addr_calc_iir_write_calc_counter_N198 FE_OFN1290_iir_enable n3498
+ NAND2X1TS
XU255 router_addr_calc_iir_write_calc_counter_N197 FE_OFN1292_iir_enable n3499
+ NAND2X1TS
XU257 router_addr_calc_iir_write_calc_counter_N196 FE_OFN1292_iir_enable n3500
+ NAND2X1TS
XU259 router_addr_calc_iir_write_calc_counter_N195 FE_OFN1292_iir_enable n3501
+ NAND2X1TS
XU261 router_addr_calc_iir_write_calc_counter_N194 FE_OFN1297_iir_enable n3502
+ NAND2X1TS
XU263 router_addr_calc_iir_write_calc_counter_N193 FE_OFN1294_iir_enable n3503
+ NAND2X1TS
XU265 router_addr_calc_iir_write_calc_counter_N192 FE_OFN1297_iir_enable n3504
+ NAND2X1TS
XU267 router_addr_calc_iir_write_calc_counter_N191 FE_OFN1297_iir_enable n3505
+ NAND2X1TS
XU279 router_addr_calc_iir_write_calc_counter_N185 FE_OFN1299_iir_enable n3511
+ NAND2X1TS
XU281 router_addr_calc_iir_write_calc_counter_N184 FE_OFN1299_iir_enable n3512
+ NAND2X1TS
XU283 router_addr_calc_iir_write_calc_counter_N183 FE_OFN1295_iir_enable n3513
+ NAND2X1TS
XU285 router_addr_calc_iir_write_calc_counter_N182 FE_OFN1295_iir_enable n3514
+ NAND2X1TS
XU289 router_addr_calc_iir_write_calc_counter_N180 FE_OFN1300_iir_enable n3516
+ NAND2X1TS
XU291 router_addr_calc_iir_write_calc_counter_N179 FE_OFN1300_iir_enable n3517
+ NAND2X1TS
XU293 router_addr_calc_iir_write_calc_counter_N178 FE_OFN1300_iir_enable n3518
+ NAND2X1TS
XU308 router_addr_calc_fir_write_calc_counter_N208 fir_enable n3532 NAND2X1TS
XU310 router_addr_calc_fir_write_calc_counter_N207 fir_enable n3533 NAND2X1TS
XU312 router_addr_calc_fir_write_calc_counter_N206 n9421 n3534 NAND2X1TS
XU314 router_addr_calc_fir_write_calc_counter_N205 n9421 n3535 NAND2X1TS
XU316 router_addr_calc_fir_write_calc_counter_N204 n9421 n3536 NAND2X1TS
XU318 router_addr_calc_fir_write_calc_counter_N203 n9421 n3537 NAND2X1TS
XU320 router_addr_calc_fir_write_calc_counter_N202 n9420 n3538 NAND2X1TS
XU322 router_addr_calc_fir_write_calc_counter_N201 n9420 n3539 NAND2X1TS
XU324 router_addr_calc_fir_write_calc_counter_N200 n9420 n3540 NAND2X1TS
XU326 router_addr_calc_fir_write_calc_counter_N199 n9420 n3541 NAND2X1TS
XU328 router_addr_calc_fir_write_calc_counter_N198 n9419 n3542 NAND2X1TS
XU330 router_addr_calc_fir_write_calc_counter_N197 n9419 n3543 NAND2X1TS
XU332 router_addr_calc_fir_write_calc_counter_N196 n9419 n3544 NAND2X1TS
XU334 router_addr_calc_fir_write_calc_counter_N195 n9419 n3545 NAND2X1TS
XU336 router_addr_calc_fir_write_calc_counter_N194 n9418 n3546 NAND2X1TS
XU338 router_addr_calc_fir_write_calc_counter_N193 n9418 n3547 NAND2X1TS
XU340 router_addr_calc_fir_write_calc_counter_N192 n9418 n3548 NAND2X1TS
XU342 router_addr_calc_fir_write_calc_counter_N191 n9418 n3549 NAND2X1TS
XU344 router_addr_calc_fir_write_calc_counter_N190 n9417 n3550 NAND2X1TS
XU348 router_addr_calc_fir_write_calc_counter_N188 n9417 n3552 NAND2X1TS
XU352 router_addr_calc_fir_write_calc_counter_N186 n9416 n3554 NAND2X1TS
XU354 router_addr_calc_fir_write_calc_counter_N185 n9416 n3555 NAND2X1TS
XU356 router_addr_calc_fir_write_calc_counter_N184 n9416 n3556 NAND2X1TS
XU358 router_addr_calc_fir_write_calc_counter_N183 n9416 n3557 NAND2X1TS
XU360 router_addr_calc_fir_write_calc_counter_N182 n9415 n3558 NAND2X1TS
XU362 router_addr_calc_fir_write_calc_counter_N181 n9415 n3559 NAND2X1TS
XU364 router_addr_calc_fir_write_calc_counter_N180 n9415 n3560 NAND2X1TS
XU366 router_addr_calc_fir_write_calc_counter_N179 n9415 n3561 NAND2X1TS
XU368 router_addr_calc_fir_write_calc_counter_N178 n9414 n3562 NAND2X1TS
XU381 router_addr_calc_fir_read_calc_counter_N209 n9414 n3573 NAND2X1TS
XU383 router_addr_calc_fir_read_calc_counter_N208 n9414 n3576 NAND2X1TS
XU385 router_addr_calc_fir_read_calc_counter_N207 n9414 n3577 NAND2X1TS
XU387 router_addr_calc_fir_read_calc_counter_N206 n9413 n3578 NAND2X1TS
XU389 router_addr_calc_fir_read_calc_counter_N205 n9413 n3579 NAND2X1TS
XU391 router_addr_calc_fir_read_calc_counter_N204 n9413 n3580 NAND2X1TS
XU393 router_addr_calc_fir_read_calc_counter_N203 n9412 n3581 NAND2X1TS
XU395 router_addr_calc_fir_read_calc_counter_N202 n9412 n3582 NAND2X1TS
XU397 router_addr_calc_fir_read_calc_counter_N201 n9412 n3583 NAND2X1TS
XU399 router_addr_calc_fir_read_calc_counter_N200 n9412 n3584 NAND2X1TS
XU401 router_addr_calc_fir_read_calc_counter_N199 n9411 n3585 NAND2X1TS
XU403 router_addr_calc_fir_read_calc_counter_N198 n9411 n3586 NAND2X1TS
XU405 router_addr_calc_fir_read_calc_counter_N197 n9411 n3587 NAND2X1TS
XU407 router_addr_calc_fir_read_calc_counter_N196 n9411 n3588 NAND2X1TS
XU409 router_addr_calc_fir_read_calc_counter_N195 n9615 n3589 NAND2X1TS
XU411 router_addr_calc_fir_read_calc_counter_N194 fir_enable n3590 NAND2X1TS
XU413 router_addr_calc_fir_read_calc_counter_N193 fir_enable n3591 NAND2X1TS
XU415 router_addr_calc_fir_read_calc_counter_N192 n9615 n3592 NAND2X1TS
XU417 router_addr_calc_fir_read_calc_counter_N191 n9410 n3593 NAND2X1TS
XU419 router_addr_calc_fir_read_calc_counter_N190 n9410 n3594 NAND2X1TS
XU423 router_addr_calc_fir_read_calc_counter_N188 n9410 n3596 NAND2X1TS
XU427 router_addr_calc_fir_read_calc_counter_N186 n9409 n3598 NAND2X1TS
XU429 router_addr_calc_fir_read_calc_counter_N185 n9409 n3599 NAND2X1TS
XU431 router_addr_calc_fir_read_calc_counter_N184 n9409 n3600 NAND2X1TS
XU433 router_addr_calc_fir_read_calc_counter_N183 n9409 n3601 NAND2X1TS
XU435 router_addr_calc_fir_read_calc_counter_N182 n9408 n3602 NAND2X1TS
XU437 router_addr_calc_fir_read_calc_counter_N181 n9408 n3603 NAND2X1TS
XU439 router_addr_calc_fir_read_calc_counter_N180 n9408 n3604 NAND2X1TS
XU441 router_addr_calc_fir_read_calc_counter_N179 n9408 n3605 NAND2X1TS
XU456 router_addr_calc_fft_write_calc_counter_N209 n9449 n3617 NAND2X1TS
XU458 router_addr_calc_fft_write_calc_counter_N208 fft_enable n3620 NAND2X1TS
XU460 router_addr_calc_fft_write_calc_counter_N207 n9449 n3621 NAND2X1TS
XU462 router_addr_calc_fft_write_calc_counter_N206 n9448 n3622 NAND2X1TS
XU464 router_addr_calc_fft_write_calc_counter_N205 n9449 n3623 NAND2X1TS
XU466 router_addr_calc_fft_write_calc_counter_N204 n9449 n3624 NAND2X1TS
XU468 router_addr_calc_fft_write_calc_counter_N203 n9448 n3625 NAND2X1TS
XU470 router_addr_calc_fft_write_calc_counter_N202 n9448 n3626 NAND2X1TS
XU472 router_addr_calc_fft_write_calc_counter_N201 n9448 n3627 NAND2X1TS
XU474 router_addr_calc_fft_write_calc_counter_N200 n9447 n3628 NAND2X1TS
XU476 router_addr_calc_fft_write_calc_counter_N199 n9447 n3629 NAND2X1TS
XU478 router_addr_calc_fft_write_calc_counter_N198 n9447 n3630 NAND2X1TS
XU480 router_addr_calc_fft_write_calc_counter_N197 n9446 n3631 NAND2X1TS
XU482 router_addr_calc_fft_write_calc_counter_N196 n9447 n3632 NAND2X1TS
XU484 router_addr_calc_fft_write_calc_counter_N195 n9446 n3633 NAND2X1TS
XU486 router_addr_calc_fft_write_calc_counter_N194 n9445 n3634 NAND2X1TS
XU488 router_addr_calc_fft_write_calc_counter_N193 n9446 n3635 NAND2X1TS
XU490 router_addr_calc_fft_write_calc_counter_N192 n9446 n3636 NAND2X1TS
XU492 router_addr_calc_fft_write_calc_counter_N191 n9445 n3637 NAND2X1TS
XU494 router_addr_calc_fft_write_calc_counter_N190 n9445 n3638 NAND2X1TS
XU498 router_addr_calc_fft_write_calc_counter_N188 n9444 n3640 NAND2X1TS
XU502 router_addr_calc_fft_write_calc_counter_N186 n9444 n3642 NAND2X1TS
XU504 router_addr_calc_fft_write_calc_counter_N185 n9444 n3643 NAND2X1TS
XU506 router_addr_calc_fft_write_calc_counter_N184 n9443 n3644 NAND2X1TS
XU508 router_addr_calc_fft_write_calc_counter_N183 n9443 n3645 NAND2X1TS
XU510 router_addr_calc_fft_write_calc_counter_N182 n9443 n3646 NAND2X1TS
XU512 router_addr_calc_fft_write_calc_counter_N181 n9443 n3647 NAND2X1TS
XU514 router_addr_calc_fft_write_calc_counter_N180 n9442 n3648 NAND2X1TS
XU516 router_addr_calc_fft_write_calc_counter_N179 n9442 n3649 NAND2X1TS
XU518 router_addr_calc_fft_write_calc_counter_N178 n9442 n3650 NAND2X1TS
XU531 router_addr_calc_fft_read_calc_counter_N209 n9442 n3661 NAND2X1TS
XU533 router_addr_calc_fft_read_calc_counter_N208 n9441 n3664 NAND2X1TS
XU535 router_addr_calc_fft_read_calc_counter_N207 n9441 n3665 NAND2X1TS
XU537 router_addr_calc_fft_read_calc_counter_N206 n9441 n3666 NAND2X1TS
XU539 router_addr_calc_fft_read_calc_counter_N205 n9440 n3667 NAND2X1TS
XU541 router_addr_calc_fft_read_calc_counter_N204 n9440 n3668 NAND2X1TS
XU543 router_addr_calc_fft_read_calc_counter_N203 n9440 n3669 NAND2X1TS
XU545 router_addr_calc_fft_read_calc_counter_N202 n9440 n3670 NAND2X1TS
XU547 router_addr_calc_fft_read_calc_counter_N201 n9439 n3671 NAND2X1TS
XU551 router_addr_calc_fft_read_calc_counter_N199 n9439 n3673 NAND2X1TS
XU555 router_addr_calc_fft_read_calc_counter_N197 n9438 n3675 NAND2X1TS
XU557 router_addr_calc_fft_read_calc_counter_N196 n9438 n3676 NAND2X1TS
XU559 router_addr_calc_fft_read_calc_counter_N195 n9438 n3677 NAND2X1TS
XU561 router_addr_calc_fft_read_calc_counter_N194 n9438 n3678 NAND2X1TS
XU563 router_addr_calc_fft_read_calc_counter_N193 n9437 n3679 NAND2X1TS
XU565 router_addr_calc_fft_read_calc_counter_N192 n9437 n3680 NAND2X1TS
XU567 router_addr_calc_fft_read_calc_counter_N191 n9437 n3681 NAND2X1TS
XU569 router_addr_calc_fft_read_calc_counter_N190 n9437 n3682 NAND2X1TS
XU573 router_addr_calc_fft_read_calc_counter_N188 n9436 n3684 NAND2X1TS
XU577 router_addr_calc_fft_read_calc_counter_N186 n9441 n3686 NAND2X1TS
XU579 router_addr_calc_fft_read_calc_counter_N185 n9436 n3687 NAND2X1TS
XU581 router_addr_calc_fft_read_calc_counter_N184 fft_enable n3688 NAND2X1TS
XU583 router_addr_calc_fft_read_calc_counter_N183 fft_enable n3689 NAND2X1TS
XU585 router_addr_calc_fft_read_calc_counter_N182 fft_enable n3690 NAND2X1TS
XU587 router_addr_calc_fft_read_calc_counter_N181 n9614 n3691 NAND2X1TS
XU589 router_addr_calc_fft_read_calc_counter_N180 n9435 n3692 NAND2X1TS
XU591 router_addr_calc_fft_read_calc_counter_N179 n9435 n3693 NAND2X1TS
XU593 router_addr_calc_fft_read_calc_counter_N178 n9435 n3694 NAND2X1TS
XU656 n3742 FE_OFN775_n3720 router_data_cntl_data_in[11] FE_OFN764_n3721
+ fft_data_in[11] FE_OFN754_n3722 fir_data_in[11] AOI222XLTS
XU658 n3743 FE_OFN775_n3720 router_data_cntl_data_in[10] FE_OFN764_n3721
+ fft_data_in[10] FE_OFN754_n3722 fir_data_in[10] AOI222XLTS
XU670 n3749 FE_OFN769_n3720 router_data_cntl_data_in[4] FE_OFN758_n3721
+ fft_data_in[4] FE_OFN748_n3722 fir_data_in[4] AOI222XLTS
XU688 n3763 fifo_from_fir_fifo_cell0_reg_ptok_N29 fifo_from_fir_tok_xnor_put
+ n3772 NOR3BX1TS
XU734 n3783 fifo_from_fft_fifo_cell0_reg_ptok_N29 fifo_from_fft_tok_xnor_put
+ n3792 NOR3BX1TS
XU929 n3814 fifo_to_fft_fifo_cell0_reg_ptok_N29 fifo_to_fft_tok_xnor_put n4006
+ NOR3BX1TS
XU950 n4023 FE_OFN729_n8058 fifo_to_fft_fifo_cell0_reg_ptok_N29 n4004 AOI21X1TS
XU1073 n3803 fifo_to_fir_fifo_cell0_reg_ptok_N29 fifo_to_fir_tok_xnor_put n4181
+ NOR3BX1TS
XU1094 n4198 FE_OFN732_n8057 fifo_to_fir_fifo_cell0_reg_ptok_N29 n4179
+ AOI21X1TS
XU1105 n4202 FE_OFN843_n7619 n4203 n4204 FE_OFN985_n9431 NOR4XLTS
XU1499 n5757 FE_OFN167_n4495 FE_OFN1550_acc_fft_data_in_13_ FE_OFN159_n4496
+ fifo_from_fft_fifo_cell14_sr_out[13] AO22X1TS
XU1867 n6095 FE_OFN311_n4555 FE_OFN1538_acc_fft_data_in_15_ FE_OFN293_n4556
+ fifo_from_fft_fifo_cell4_sr_out[15] AO22X1TS
XU2017 n4595 FE_OFN696_n8052 fifo_from_fft_fifo_cell0_reg_ptok_N29 n3789
+ AOI21X1TS
XU2130 n6286 FE_OFN507_n4681 FE_OFN1731_acc_fir_data_in_13_ FE_OFN495_n4682
+ fifo_from_fir_fifo_cell14_sr_out[13] AO22X1TS
XU2498 n6624 FE_OFN651_n4741 FE_OFN1723_acc_fir_data_in_15_ FE_OFN639_n4742
+ fifo_from_fir_fifo_cell4_sr_out[15] AO22X1TS
XU2648 n4781 FE_OFN681_n8050 fifo_from_fir_fifo_cell0_reg_ptok_N29 n3769
+ AOI21X1TS
XU2720 n3838 n3834 n3835 NAND2X1TS
XU2730 n6764 n9390 n4457 n4449 FE_OFN839_n7619 n4456 router_iir_write_done
+ OAI33XLTS
XU2734 n4457 n3846 n4200 NAND2X1TS
XU2735 n4200 instruction[1] n4841 NAND2X1TS
XU3387 n5207 fifo_to_fir_fifo_cell1_data_out_N35 n4132 NAND2X1TS
XU3400 n5213 n5214 n5215 XNOR2X1TS
XU3401 n5215 n5216 n5217 XOR2X1TS
XU3402 n5217 n4123 n5218 XNOR2X1TS
XU3408 n5216 n5219 n5220 XOR2X1TS
XU3413 n4113 fifo_to_fir_fifo_cell3_reg_gtok_token FE_OFN686_n4134 NAND2X1TS
XU3419 n5214 n5221 n5222 XOR2X1TS
XU3420 n5222 n5223 n5224 XOR2X1TS
XU3431 n5221 n5225 n5226 XOR2X1TS
XU3530 n5249 fifo_to_fft_fifo_cell1_data_out_N35 n3957 NAND2X1TS
XU3544 n5255 n5256 n5257 XNOR2X1TS
XU3545 n5257 n5258 n5259 XOR2X1TS
XU3546 n5259 n3948 n5260 XNOR2X1TS
XU3552 n5258 n5261 n5262 XOR2X1TS
XU3563 n5256 n5263 n5264 XOR2X1TS
XU3564 n5264 n5265 n5266 XOR2X1TS
XU3575 n5263 n5267 n5268 XOR2X1TS
XU3673 n4759 n8877 n5288 NOR2X1TS
XU3816 n4573 n8844 n5327 NOR2X1TS
Xmips_mips_a_countflag_reg mips_mips_a_countflag n3440 mips_mips_a_N49
+ mips_mips_a_N50 TLATXLTS
Xrouter_data_cntl_data_from_iir_reg router_data_from_iir n2634 n7606
+ router_data_cntl_N142 TLATXLTS
Xrouter_data_cntl_data_to_fir_reg router_data_to_fir n3843
+ router_data_cntl_N137 router_data_cntl_N138 TLATXLTS
Xrouter_data_cntl_data_from_fft_reg router_data_from_fft n3840
+ router_data_cntl_N133 router_data_cntl_N134 TLATXLTS
Xrouter_data_cntl_data_to_fft_reg router_data_to_fft n3841
+ router_data_cntl_N135 router_data_cntl_N134 TLATXLTS
Xrouter_data_cntl_data_from_fir_reg router_data_from_fir n2633
+ router_data_cntl_N139 router_data_cntl_N138 TLATXLTS
Xfifo_to_fft_fifo_cell0_data_out_en_reg fifo_to_fft_fifo_cell0_control_signal
+ clk__L1_N0 fifo_to_fft_fifo_cell0_data_out_N35 DFFQX1TS
Xfifo_to_fir_fifo_cell0_data_out_en_reg fifo_to_fir_fifo_cell0_control_signal
+ clk__L1_N0 fifo_to_fir_fifo_cell0_data_out_N35 DFFQX1TS
Xfifo_to_fir_fifo_cell0_hold_token_reg fifo_to_fir_hold[0] clk__L1_N0
+ fifo_to_fir_fifo_cell0_N7 DFFQX1TS
Xfifo_to_fft_fifo_cell0_hold_token_reg fifo_to_fft_hold[0] clk__L1_N0
+ fifo_to_fft_fifo_cell0_N7 DFFQX1TS
Xmips_mips_a_count_reg[0] mips_mips_a_count[0] clk__L1_N0 n5701 DFFQX1TS
Xmips_mips_a_count_reg[1] 1185 n4441 clk__L1_N0 n5700 DFFXLTS
Xfifo_from_fir_fifo_cell0_reg_ptok_out_valid_get_reg 1186
+ fifo_from_fir_fifo_cell0_reg_ptok_out_valid_get clk__L1_N0 n9547 n5288
+ DFFTRX2TS
Xfifo_to_fir_fifo_cell0_reg_ptok_out_valid_get_reg 1187
+ fifo_to_fir_fifo_cell0_reg_ptok_out_valid_get clk__L1_N0 n9547 n5208
+ DFFTRX2TS
Xfifo_from_fft_fifo_cell0_reg_ptok_out_valid_get_reg 1188
+ fifo_from_fft_fifo_cell0_reg_ptok_out_valid_get clk__L1_N0 n9546 n5327
+ DFFTRX2TS
Xfifo_to_fft_fifo_cell0_reg_ptok_out_valid_get_reg 1189
+ fifo_to_fft_fifo_cell0_reg_ptok_out_valid_get clk__L1_N0 n9547 n5250
+ DFFTRX2TS
Xfifo_from_fir_fifo_cell0_register_sr_reg[31]
+ fifo_from_fir_fifo_cell0_sr_out[31] clk__L1_N0 n5385 DFFQX1TS
Xfifo_from_fir_fifo_cell0_register_sr_reg[30]
+ fifo_from_fir_fifo_cell0_sr_out[30] clk__L1_N0 n5386 DFFQX1TS
Xfifo_from_fir_fifo_cell0_register_sr_reg[29]
+ fifo_from_fir_fifo_cell0_sr_out[29] clk__L1_N0 n5387 DFFQX1TS
Xfifo_from_fir_fifo_cell0_register_sr_reg[28]
+ fifo_from_fir_fifo_cell0_sr_out[28] clk__L1_N0 n5388 DFFQX1TS
Xfifo_from_fir_fifo_cell0_register_sr_reg[27]
+ fifo_from_fir_fifo_cell0_sr_out[27] clk__L1_N0 n5389 DFFQX1TS
Xfifo_from_fir_fifo_cell0_register_sr_reg[26]
+ fifo_from_fir_fifo_cell0_sr_out[26] clk__L1_N0 n5390 DFFQX1TS
Xfifo_from_fir_fifo_cell0_register_sr_reg[25]
+ fifo_from_fir_fifo_cell0_sr_out[25] clk__L1_N0 n5391 DFFQX1TS
Xfifo_from_fir_fifo_cell0_register_sr_reg[24]
+ fifo_from_fir_fifo_cell0_sr_out[24] clk__L1_N0 n5392 DFFQX1TS
Xfifo_from_fir_fifo_cell0_register_sr_reg[23]
+ fifo_from_fir_fifo_cell0_sr_out[23] clk__L1_N0 n5393 DFFQX1TS
Xfifo_from_fir_fifo_cell0_register_sr_reg[22]
+ fifo_from_fir_fifo_cell0_sr_out[22] clk__L1_N0 n5394 DFFQX1TS
Xfifo_from_fir_fifo_cell0_register_sr_reg[21]
+ fifo_from_fir_fifo_cell0_sr_out[21] clk__L1_N0 n5395 DFFQX1TS
Xfifo_from_fir_fifo_cell0_register_sr_reg[20]
+ fifo_from_fir_fifo_cell0_sr_out[20] clk__L1_N0 n5396 DFFQX1TS
Xfifo_from_fir_fifo_cell0_register_sr_reg[19]
+ fifo_from_fir_fifo_cell0_sr_out[19] clk__L1_N0 n5397 DFFQX1TS
Xfifo_from_fir_fifo_cell0_register_sr_reg[18]
+ fifo_from_fir_fifo_cell0_sr_out[18] clk__L1_N0 n5398 DFFQX1TS
Xfifo_from_fir_fifo_cell0_register_sr_reg[17]
+ fifo_from_fir_fifo_cell0_sr_out[17] clk__L1_N0 n5399 DFFQX1TS
Xfifo_from_fir_fifo_cell0_register_sr_reg[16]
+ fifo_from_fir_fifo_cell0_sr_out[16] clk__L1_N0 n5400 DFFQX1TS
Xfifo_from_fir_fifo_cell0_register_sr_reg[15]
+ fifo_from_fir_fifo_cell0_sr_out[15] clk__L1_N0 n5401 DFFQX1TS
Xfifo_from_fir_fifo_cell0_register_sr_reg[14]
+ fifo_from_fir_fifo_cell0_sr_out[14] clk__L1_N0 n5402 DFFQX1TS
Xfifo_from_fir_fifo_cell0_register_sr_reg[13]
+ fifo_from_fir_fifo_cell0_sr_out[13] clk__L1_N0 n5403 DFFQX1TS
Xfifo_from_fir_fifo_cell0_register_sr_reg[12]
+ fifo_from_fir_fifo_cell0_sr_out[12] clk__L1_N0 n5404 DFFQX1TS
Xfifo_from_fir_fifo_cell0_register_sr_reg[11]
+ fifo_from_fir_fifo_cell0_sr_out[11] clk__L1_N0 n5405 DFFQX1TS
Xfifo_from_fir_fifo_cell0_register_sr_reg[10]
+ fifo_from_fir_fifo_cell0_sr_out[10] clk__L1_N0 n5406 DFFQX1TS
Xfifo_from_fir_fifo_cell0_register_sr_reg[9] fifo_from_fir_fifo_cell0_sr_out[9]
+ clk__L1_N0 n5407 DFFQX1TS
Xfifo_from_fir_fifo_cell0_register_sr_reg[8] fifo_from_fir_fifo_cell0_sr_out[8]
+ clk__L1_N0 n5408 DFFQX1TS
Xfifo_from_fir_fifo_cell0_register_sr_reg[7] fifo_from_fir_fifo_cell0_sr_out[7]
+ clk__L1_N0 n5409 DFFQX1TS
Xfifo_from_fir_fifo_cell0_register_sr_reg[6] fifo_from_fir_fifo_cell0_sr_out[6]
+ clk__L1_N0 n5410 DFFQX1TS
Xfifo_from_fir_fifo_cell0_register_sr_reg[5] fifo_from_fir_fifo_cell0_sr_out[5]
+ clk__L1_N0 n5411 DFFQX1TS
Xfifo_from_fir_fifo_cell0_register_sr_reg[4] fifo_from_fir_fifo_cell0_sr_out[4]
+ clk__L1_N0 n5412 DFFQX1TS
Xfifo_from_fir_fifo_cell0_register_sr_reg[3] fifo_from_fir_fifo_cell0_sr_out[3]
+ clk__L1_N0 n5413 DFFQX1TS
Xfifo_from_fir_fifo_cell0_register_sr_reg[2] fifo_from_fir_fifo_cell0_sr_out[2]
+ clk__L1_N0 n5414 DFFQX1TS
Xfifo_from_fir_fifo_cell0_register_sr_reg[1] fifo_from_fir_fifo_cell0_sr_out[1]
+ clk__L1_N0 n5415 DFFQX1TS
Xfifo_from_fir_fifo_cell0_register_sr_reg[0] fifo_from_fir_fifo_cell0_sr_out[0]
+ clk__L1_N0 n5416 DFFQX1TS
Xfifo_from_fir_fifo_cell1_register_sr_reg[31]
+ fifo_from_fir_fifo_cell1_sr_out[31] clk__L1_N0 n6710 DFFQX1TS
Xfifo_from_fir_fifo_cell1_register_sr_reg[30]
+ fifo_from_fir_fifo_cell1_sr_out[30] clk__L1_N0 n6711 DFFQX1TS
Xfifo_from_fir_fifo_cell1_register_sr_reg[29]
+ fifo_from_fir_fifo_cell1_sr_out[29] clk__L1_N0 n6712 DFFQX1TS
Xfifo_from_fir_fifo_cell1_register_sr_reg[28]
+ fifo_from_fir_fifo_cell1_sr_out[28] clk__L1_N0 n6713 DFFQX1TS
Xfifo_from_fir_fifo_cell1_register_sr_reg[27]
+ fifo_from_fir_fifo_cell1_sr_out[27] clk__L1_N0 n6714 DFFQX1TS
Xfifo_from_fir_fifo_cell1_register_sr_reg[26]
+ fifo_from_fir_fifo_cell1_sr_out[26] clk__L1_N0 n6715 DFFQX1TS
Xfifo_from_fir_fifo_cell1_register_sr_reg[25]
+ fifo_from_fir_fifo_cell1_sr_out[25] clk__L1_N0 n6716 DFFQX1TS
Xfifo_from_fir_fifo_cell1_register_sr_reg[24]
+ fifo_from_fir_fifo_cell1_sr_out[24] clk__L1_N0 n6717 DFFQX1TS
Xfifo_from_fir_fifo_cell1_register_sr_reg[23]
+ fifo_from_fir_fifo_cell1_sr_out[23] clk__L1_N0 n6718 DFFQX1TS
Xfifo_from_fir_fifo_cell1_register_sr_reg[22]
+ fifo_from_fir_fifo_cell1_sr_out[22] clk__L1_N0 n6719 DFFQX1TS
Xfifo_from_fir_fifo_cell1_register_sr_reg[21]
+ fifo_from_fir_fifo_cell1_sr_out[21] clk__L1_N0 n6720 DFFQX1TS
Xfifo_from_fir_fifo_cell1_register_sr_reg[20]
+ fifo_from_fir_fifo_cell1_sr_out[20] clk__L1_N0 n6721 DFFQX1TS
Xfifo_from_fir_fifo_cell1_register_sr_reg[19]
+ fifo_from_fir_fifo_cell1_sr_out[19] clk__L1_N0 n6722 DFFQX1TS
Xfifo_from_fir_fifo_cell1_register_sr_reg[18]
+ fifo_from_fir_fifo_cell1_sr_out[18] clk__L1_N0 n6723 DFFQX1TS
Xfifo_from_fir_fifo_cell1_register_sr_reg[17]
+ fifo_from_fir_fifo_cell1_sr_out[17] clk__L1_N0 n6724 DFFQX1TS
Xfifo_from_fir_fifo_cell1_register_sr_reg[16]
+ fifo_from_fir_fifo_cell1_sr_out[16] clk__L1_N0 n6725 DFFQX1TS
Xfifo_from_fir_fifo_cell1_register_sr_reg[15]
+ fifo_from_fir_fifo_cell1_sr_out[15] clk__L1_N0 n6726 DFFQX1TS
Xfifo_from_fir_fifo_cell1_register_sr_reg[14]
+ fifo_from_fir_fifo_cell1_sr_out[14] clk__L1_N0 n6727 DFFQX1TS
Xfifo_from_fir_fifo_cell1_register_sr_reg[13]
+ fifo_from_fir_fifo_cell1_sr_out[13] clk__L1_N0 n6728 DFFQX1TS
Xfifo_from_fir_fifo_cell1_register_sr_reg[12]
+ fifo_from_fir_fifo_cell1_sr_out[12] clk__L1_N0 n6729 DFFQX1TS
Xfifo_from_fir_fifo_cell1_register_sr_reg[11]
+ fifo_from_fir_fifo_cell1_sr_out[11] clk__L1_N0 n6730 DFFQX1TS
Xfifo_from_fir_fifo_cell1_register_sr_reg[10]
+ fifo_from_fir_fifo_cell1_sr_out[10] clk__L1_N0 n6731 DFFQX1TS
Xfifo_from_fir_fifo_cell1_register_sr_reg[9] fifo_from_fir_fifo_cell1_sr_out[9]
+ clk__L1_N0 n6732 DFFQX1TS
Xfifo_from_fir_fifo_cell1_register_sr_reg[8] fifo_from_fir_fifo_cell1_sr_out[8]
+ clk__L1_N0 n6733 DFFQX1TS
Xfifo_from_fir_fifo_cell1_register_sr_reg[7] fifo_from_fir_fifo_cell1_sr_out[7]
+ clk__L1_N0 n6734 DFFQX1TS
Xfifo_from_fir_fifo_cell1_register_sr_reg[6] fifo_from_fir_fifo_cell1_sr_out[6]
+ clk__L1_N0 n6735 DFFQX1TS
Xfifo_from_fir_fifo_cell1_register_sr_reg[5] fifo_from_fir_fifo_cell1_sr_out[5]
+ clk__L1_N0 n6736 DFFQX1TS
Xfifo_from_fir_fifo_cell1_register_sr_reg[4] fifo_from_fir_fifo_cell1_sr_out[4]
+ clk__L1_N0 n6737 DFFQX1TS
Xfifo_from_fir_fifo_cell1_register_sr_reg[3] fifo_from_fir_fifo_cell1_sr_out[3]
+ clk__L1_N0 n6738 DFFQX1TS
Xfifo_from_fir_fifo_cell1_register_sr_reg[2] fifo_from_fir_fifo_cell1_sr_out[2]
+ clk__L1_N0 n6739 DFFQX1TS
Xfifo_from_fir_fifo_cell1_register_sr_reg[1] fifo_from_fir_fifo_cell1_sr_out[1]
+ clk__L1_N0 n6740 DFFQX1TS
Xfifo_from_fir_fifo_cell1_register_sr_reg[0] fifo_from_fir_fifo_cell1_sr_out[0]
+ clk__L1_N0 n6741 DFFQX1TS
Xfifo_from_fir_fifo_cell2_register_sr_reg[31]
+ fifo_from_fir_fifo_cell2_sr_out[31] clk__L1_N0 n6676 DFFQX1TS
Xfifo_from_fir_fifo_cell2_register_sr_reg[30]
+ fifo_from_fir_fifo_cell2_sr_out[30] clk__L1_N0 n6677 DFFQX1TS
Xfifo_from_fir_fifo_cell2_register_sr_reg[29]
+ fifo_from_fir_fifo_cell2_sr_out[29] clk__L1_N0 n6678 DFFQX1TS
Xfifo_from_fir_fifo_cell2_register_sr_reg[28]
+ fifo_from_fir_fifo_cell2_sr_out[28] clk__L1_N0 n6679 DFFQX1TS
Xfifo_from_fir_fifo_cell2_register_sr_reg[27]
+ fifo_from_fir_fifo_cell2_sr_out[27] clk__L1_N0 n6680 DFFQX1TS
Xfifo_from_fir_fifo_cell2_register_sr_reg[26]
+ fifo_from_fir_fifo_cell2_sr_out[26] clk__L1_N0 n6681 DFFQX1TS
Xfifo_from_fir_fifo_cell2_register_sr_reg[25]
+ fifo_from_fir_fifo_cell2_sr_out[25] clk__L1_N0 n6682 DFFQX1TS
Xfifo_from_fir_fifo_cell2_register_sr_reg[24]
+ fifo_from_fir_fifo_cell2_sr_out[24] clk__L1_N0 n6683 DFFQX1TS
Xfifo_from_fir_fifo_cell2_register_sr_reg[23]
+ fifo_from_fir_fifo_cell2_sr_out[23] clk__L1_N0 n6684 DFFQX1TS
Xfifo_from_fir_fifo_cell2_register_sr_reg[22]
+ fifo_from_fir_fifo_cell2_sr_out[22] clk__L1_N0 n6685 DFFQX1TS
Xfifo_from_fir_fifo_cell2_register_sr_reg[21]
+ fifo_from_fir_fifo_cell2_sr_out[21] clk__L1_N0 n6686 DFFQX1TS
Xfifo_from_fir_fifo_cell2_register_sr_reg[20]
+ fifo_from_fir_fifo_cell2_sr_out[20] clk__L1_N0 n6687 DFFQX1TS
Xfifo_from_fir_fifo_cell2_register_sr_reg[19]
+ fifo_from_fir_fifo_cell2_sr_out[19] clk__L1_N0 n6688 DFFQX1TS
Xfifo_from_fir_fifo_cell2_register_sr_reg[18]
+ fifo_from_fir_fifo_cell2_sr_out[18] clk__L1_N0 n6689 DFFQX1TS
Xfifo_from_fir_fifo_cell2_register_sr_reg[17]
+ fifo_from_fir_fifo_cell2_sr_out[17] clk__L1_N0 n6690 DFFQX1TS
Xfifo_from_fir_fifo_cell2_register_sr_reg[16]
+ fifo_from_fir_fifo_cell2_sr_out[16] clk__L1_N0 n6691 DFFQX1TS
Xfifo_from_fir_fifo_cell2_register_sr_reg[15]
+ fifo_from_fir_fifo_cell2_sr_out[15] clk__L1_N0 n6692 DFFQX1TS
Xfifo_from_fir_fifo_cell2_register_sr_reg[14]
+ fifo_from_fir_fifo_cell2_sr_out[14] clk__L1_N0 n6693 DFFQX1TS
Xfifo_from_fir_fifo_cell2_register_sr_reg[13]
+ fifo_from_fir_fifo_cell2_sr_out[13] clk__L1_N0 n6694 DFFQX1TS
Xfifo_from_fir_fifo_cell2_register_sr_reg[12]
+ fifo_from_fir_fifo_cell2_sr_out[12] clk__L1_N0 n6695 DFFQX1TS
Xfifo_from_fir_fifo_cell2_register_sr_reg[11]
+ fifo_from_fir_fifo_cell2_sr_out[11] clk__L1_N0 n6696 DFFQX1TS
Xfifo_from_fir_fifo_cell2_register_sr_reg[10]
+ fifo_from_fir_fifo_cell2_sr_out[10] clk__L1_N0 n6697 DFFQX1TS
Xfifo_from_fir_fifo_cell2_register_sr_reg[9] fifo_from_fir_fifo_cell2_sr_out[9]
+ clk__L1_N0 n6698 DFFQX1TS
Xfifo_from_fir_fifo_cell2_register_sr_reg[8] fifo_from_fir_fifo_cell2_sr_out[8]
+ clk__L1_N0 n6699 DFFQX1TS
Xfifo_from_fir_fifo_cell2_register_sr_reg[7] fifo_from_fir_fifo_cell2_sr_out[7]
+ clk__L1_N0 n6700 DFFQX1TS
Xfifo_from_fir_fifo_cell2_register_sr_reg[6] fifo_from_fir_fifo_cell2_sr_out[6]
+ clk__L1_N0 n6701 DFFQX1TS
Xfifo_from_fir_fifo_cell2_register_sr_reg[5] fifo_from_fir_fifo_cell2_sr_out[5]
+ clk__L1_N0 n6702 DFFQX1TS
Xfifo_from_fir_fifo_cell2_register_sr_reg[4] fifo_from_fir_fifo_cell2_sr_out[4]
+ clk__L1_N0 n6703 DFFQX1TS
Xfifo_from_fir_fifo_cell2_register_sr_reg[3] fifo_from_fir_fifo_cell2_sr_out[3]
+ clk__L1_N0 n6704 DFFQX1TS
Xfifo_from_fir_fifo_cell2_register_sr_reg[2] fifo_from_fir_fifo_cell2_sr_out[2]
+ clk__L1_N0 n6705 DFFQX1TS
Xfifo_from_fir_fifo_cell2_register_sr_reg[1] fifo_from_fir_fifo_cell2_sr_out[1]
+ clk__L1_N0 n6706 DFFQX1TS
Xfifo_from_fir_fifo_cell2_register_sr_reg[0] fifo_from_fir_fifo_cell2_sr_out[0]
+ clk__L1_N0 n6707 DFFQX1TS
Xfifo_from_fir_fifo_cell3_register_sr_reg[31]
+ fifo_from_fir_fifo_cell3_sr_out[31] clk__L1_N0 n6642 DFFQX1TS
Xfifo_from_fir_fifo_cell3_register_sr_reg[30]
+ fifo_from_fir_fifo_cell3_sr_out[30] clk__L1_N0 n6643 DFFQX1TS
Xfifo_from_fir_fifo_cell3_register_sr_reg[29]
+ fifo_from_fir_fifo_cell3_sr_out[29] clk__L1_N0 n6644 DFFQX1TS
Xfifo_from_fir_fifo_cell3_register_sr_reg[28]
+ fifo_from_fir_fifo_cell3_sr_out[28] clk__L1_N0 n6645 DFFQX1TS
Xfifo_from_fir_fifo_cell3_register_sr_reg[27]
+ fifo_from_fir_fifo_cell3_sr_out[27] clk__L1_N0 n6646 DFFQX1TS
Xfifo_from_fir_fifo_cell3_register_sr_reg[26]
+ fifo_from_fir_fifo_cell3_sr_out[26] clk__L1_N0 n6647 DFFQX1TS
Xfifo_from_fir_fifo_cell3_register_sr_reg[25]
+ fifo_from_fir_fifo_cell3_sr_out[25] clk__L1_N0 n6648 DFFQX1TS
Xfifo_from_fir_fifo_cell3_register_sr_reg[24]
+ fifo_from_fir_fifo_cell3_sr_out[24] clk__L1_N0 n6649 DFFQX1TS
Xfifo_from_fir_fifo_cell3_register_sr_reg[23]
+ fifo_from_fir_fifo_cell3_sr_out[23] clk__L1_N0 n6650 DFFQX1TS
Xfifo_from_fir_fifo_cell3_register_sr_reg[22]
+ fifo_from_fir_fifo_cell3_sr_out[22] clk__L1_N0 n6651 DFFQX1TS
Xfifo_from_fir_fifo_cell3_register_sr_reg[21]
+ fifo_from_fir_fifo_cell3_sr_out[21] clk__L1_N0 n6652 DFFQX1TS
Xfifo_from_fir_fifo_cell3_register_sr_reg[20]
+ fifo_from_fir_fifo_cell3_sr_out[20] clk__L1_N0 n6653 DFFQX1TS
Xfifo_from_fir_fifo_cell3_register_sr_reg[19]
+ fifo_from_fir_fifo_cell3_sr_out[19] clk__L1_N0 n6654 DFFQX1TS
Xfifo_from_fir_fifo_cell3_register_sr_reg[18]
+ fifo_from_fir_fifo_cell3_sr_out[18] clk__L1_N0 n6655 DFFQX1TS
Xfifo_from_fir_fifo_cell3_register_sr_reg[17]
+ fifo_from_fir_fifo_cell3_sr_out[17] clk__L1_N0 n6656 DFFQX1TS
Xfifo_from_fir_fifo_cell3_register_sr_reg[16]
+ fifo_from_fir_fifo_cell3_sr_out[16] clk__L1_N0 n6657 DFFQX1TS
Xfifo_from_fir_fifo_cell3_register_sr_reg[15]
+ fifo_from_fir_fifo_cell3_sr_out[15] clk__L1_N0 n6658 DFFQX1TS
Xfifo_from_fir_fifo_cell3_register_sr_reg[14]
+ fifo_from_fir_fifo_cell3_sr_out[14] clk__L1_N0 n6659 DFFQX1TS
Xfifo_from_fir_fifo_cell3_register_sr_reg[13]
+ fifo_from_fir_fifo_cell3_sr_out[13] clk__L1_N0 n6660 DFFQX1TS
Xfifo_from_fir_fifo_cell3_register_sr_reg[12]
+ fifo_from_fir_fifo_cell3_sr_out[12] clk__L1_N0 n6661 DFFQX1TS
Xfifo_from_fir_fifo_cell3_register_sr_reg[11]
+ fifo_from_fir_fifo_cell3_sr_out[11] clk__L1_N0 n6662 DFFQX1TS
Xfifo_from_fir_fifo_cell3_register_sr_reg[10]
+ fifo_from_fir_fifo_cell3_sr_out[10] clk__L1_N0 n6663 DFFQX1TS
Xfifo_from_fir_fifo_cell3_register_sr_reg[9] fifo_from_fir_fifo_cell3_sr_out[9]
+ clk__L1_N0 n6664 DFFQX1TS
Xfifo_from_fir_fifo_cell3_register_sr_reg[8] fifo_from_fir_fifo_cell3_sr_out[8]
+ clk__L1_N0 n6665 DFFQX1TS
Xfifo_from_fir_fifo_cell3_register_sr_reg[7] fifo_from_fir_fifo_cell3_sr_out[7]
+ clk__L1_N0 n6666 DFFQX1TS
Xfifo_from_fir_fifo_cell3_register_sr_reg[6] fifo_from_fir_fifo_cell3_sr_out[6]
+ clk__L1_N0 n6667 DFFQX1TS
Xfifo_from_fir_fifo_cell3_register_sr_reg[5] fifo_from_fir_fifo_cell3_sr_out[5]
+ clk__L1_N0 n6668 DFFQX1TS
Xfifo_from_fir_fifo_cell3_register_sr_reg[4] fifo_from_fir_fifo_cell3_sr_out[4]
+ clk__L1_N0 n6669 DFFQX1TS
Xfifo_from_fir_fifo_cell3_register_sr_reg[3] fifo_from_fir_fifo_cell3_sr_out[3]
+ clk__L1_N0 n6670 DFFQX1TS
Xfifo_from_fir_fifo_cell3_register_sr_reg[2] fifo_from_fir_fifo_cell3_sr_out[2]
+ clk__L1_N0 n6671 DFFQX1TS
Xfifo_from_fir_fifo_cell3_register_sr_reg[1] fifo_from_fir_fifo_cell3_sr_out[1]
+ clk__L1_N0 n6672 DFFQX1TS
Xfifo_from_fir_fifo_cell3_register_sr_reg[0] fifo_from_fir_fifo_cell3_sr_out[0]
+ clk__L1_N0 n6673 DFFQX1TS
Xfifo_from_fir_fifo_cell4_register_sr_reg[31]
+ fifo_from_fir_fifo_cell4_sr_out[31] clk__L1_N0 n6608 DFFQX1TS
Xfifo_from_fir_fifo_cell4_register_sr_reg[30]
+ fifo_from_fir_fifo_cell4_sr_out[30] clk__L1_N0 n6609 DFFQX1TS
Xfifo_from_fir_fifo_cell4_register_sr_reg[29]
+ fifo_from_fir_fifo_cell4_sr_out[29] clk__L1_N0 n6610 DFFQX1TS
Xfifo_from_fir_fifo_cell4_register_sr_reg[28]
+ fifo_from_fir_fifo_cell4_sr_out[28] clk__L1_N0 n6611 DFFQX1TS
Xfifo_from_fir_fifo_cell4_register_sr_reg[27]
+ fifo_from_fir_fifo_cell4_sr_out[27] clk__L1_N0 n6612 DFFQX1TS
Xfifo_from_fir_fifo_cell4_register_sr_reg[26]
+ fifo_from_fir_fifo_cell4_sr_out[26] clk__L1_N0 n6613 DFFQX1TS
Xfifo_from_fir_fifo_cell4_register_sr_reg[25]
+ fifo_from_fir_fifo_cell4_sr_out[25] clk__L1_N0 n6614 DFFQX1TS
Xfifo_from_fir_fifo_cell4_register_sr_reg[24]
+ fifo_from_fir_fifo_cell4_sr_out[24] clk__L1_N0 n6615 DFFQX1TS
Xfifo_from_fir_fifo_cell4_register_sr_reg[23]
+ fifo_from_fir_fifo_cell4_sr_out[23] clk__L1_N0 n6616 DFFQX1TS
Xfifo_from_fir_fifo_cell4_register_sr_reg[22]
+ fifo_from_fir_fifo_cell4_sr_out[22] clk__L1_N0 n6617 DFFQX1TS
Xfifo_from_fir_fifo_cell4_register_sr_reg[21]
+ fifo_from_fir_fifo_cell4_sr_out[21] clk__L1_N0 n6618 DFFQX1TS
Xfifo_from_fir_fifo_cell4_register_sr_reg[20]
+ fifo_from_fir_fifo_cell4_sr_out[20] clk__L1_N0 n6619 DFFQX1TS
Xfifo_from_fir_fifo_cell4_register_sr_reg[19]
+ fifo_from_fir_fifo_cell4_sr_out[19] clk__L1_N0 n6620 DFFQX1TS
Xfifo_from_fir_fifo_cell4_register_sr_reg[18]
+ fifo_from_fir_fifo_cell4_sr_out[18] clk__L1_N0 n6621 DFFQX1TS
Xfifo_from_fir_fifo_cell4_register_sr_reg[17]
+ fifo_from_fir_fifo_cell4_sr_out[17] clk__L1_N0 n6622 DFFQX1TS
Xfifo_from_fir_fifo_cell4_register_sr_reg[16]
+ fifo_from_fir_fifo_cell4_sr_out[16] clk__L1_N0 n6623 DFFQX1TS
Xfifo_from_fir_fifo_cell4_register_sr_reg[15]
+ fifo_from_fir_fifo_cell4_sr_out[15] clk__L1_N0 n6624 DFFQX1TS
Xfifo_from_fir_fifo_cell4_register_sr_reg[14]
+ fifo_from_fir_fifo_cell4_sr_out[14] clk__L1_N0 n6625 DFFQX1TS
Xfifo_from_fir_fifo_cell4_register_sr_reg[13]
+ fifo_from_fir_fifo_cell4_sr_out[13] clk__L1_N0 n6626 DFFQX1TS
Xfifo_from_fir_fifo_cell4_register_sr_reg[12]
+ fifo_from_fir_fifo_cell4_sr_out[12] clk__L1_N0 n6627 DFFQX1TS
Xfifo_from_fir_fifo_cell4_register_sr_reg[11]
+ fifo_from_fir_fifo_cell4_sr_out[11] clk__L1_N0 n6628 DFFQX1TS
Xfifo_from_fir_fifo_cell4_register_sr_reg[10]
+ fifo_from_fir_fifo_cell4_sr_out[10] clk__L1_N0 n6629 DFFQX1TS
Xfifo_from_fir_fifo_cell4_register_sr_reg[9] fifo_from_fir_fifo_cell4_sr_out[9]
+ clk__L1_N0 n6630 DFFQX1TS
Xfifo_from_fir_fifo_cell4_register_sr_reg[8] fifo_from_fir_fifo_cell4_sr_out[8]
+ clk__L1_N0 n6631 DFFQX1TS
Xfifo_from_fir_fifo_cell4_register_sr_reg[7] fifo_from_fir_fifo_cell4_sr_out[7]
+ clk__L1_N0 n6632 DFFQX1TS
Xfifo_from_fir_fifo_cell4_register_sr_reg[6] fifo_from_fir_fifo_cell4_sr_out[6]
+ clk__L1_N0 n6633 DFFQX1TS
Xfifo_from_fir_fifo_cell4_register_sr_reg[5] fifo_from_fir_fifo_cell4_sr_out[5]
+ clk__L1_N0 n6634 DFFQX1TS
Xfifo_from_fir_fifo_cell4_register_sr_reg[4] fifo_from_fir_fifo_cell4_sr_out[4]
+ clk__L1_N0 n6635 DFFQX1TS
Xfifo_from_fir_fifo_cell4_register_sr_reg[3] fifo_from_fir_fifo_cell4_sr_out[3]
+ clk__L1_N0 n6636 DFFQX1TS
Xfifo_from_fir_fifo_cell4_register_sr_reg[2] fifo_from_fir_fifo_cell4_sr_out[2]
+ clk__L1_N0 n6637 DFFQX1TS
Xfifo_from_fir_fifo_cell4_register_sr_reg[1] fifo_from_fir_fifo_cell4_sr_out[1]
+ clk__L1_N0 n6638 DFFQX1TS
Xfifo_from_fir_fifo_cell4_register_sr_reg[0] fifo_from_fir_fifo_cell4_sr_out[0]
+ clk__L1_N0 n6639 DFFQX1TS
Xfifo_from_fir_fifo_cell5_register_sr_reg[31]
+ fifo_from_fir_fifo_cell5_sr_out[31] clk__L1_N0 n6574 DFFQX1TS
Xfifo_from_fir_fifo_cell5_register_sr_reg[30]
+ fifo_from_fir_fifo_cell5_sr_out[30] clk__L1_N0 n6575 DFFQX1TS
Xfifo_from_fir_fifo_cell5_register_sr_reg[29]
+ fifo_from_fir_fifo_cell5_sr_out[29] clk__L1_N0 n6576 DFFQX1TS
Xfifo_from_fir_fifo_cell5_register_sr_reg[28]
+ fifo_from_fir_fifo_cell5_sr_out[28] clk__L1_N0 n6577 DFFQX1TS
Xfifo_from_fir_fifo_cell5_register_sr_reg[27]
+ fifo_from_fir_fifo_cell5_sr_out[27] clk__L1_N0 n6578 DFFQX1TS
Xfifo_from_fir_fifo_cell5_register_sr_reg[26]
+ fifo_from_fir_fifo_cell5_sr_out[26] clk__L1_N0 n6579 DFFQX1TS
Xfifo_from_fir_fifo_cell5_register_sr_reg[25]
+ fifo_from_fir_fifo_cell5_sr_out[25] clk__L1_N0 n6580 DFFQX1TS
Xfifo_from_fir_fifo_cell5_register_sr_reg[24]
+ fifo_from_fir_fifo_cell5_sr_out[24] clk__L1_N0 n6581 DFFQX1TS
Xfifo_from_fir_fifo_cell5_register_sr_reg[23]
+ fifo_from_fir_fifo_cell5_sr_out[23] clk__L1_N0 n6582 DFFQX1TS
Xfifo_from_fir_fifo_cell5_register_sr_reg[22]
+ fifo_from_fir_fifo_cell5_sr_out[22] clk__L1_N0 n6583 DFFQX1TS
Xfifo_from_fir_fifo_cell5_register_sr_reg[21]
+ fifo_from_fir_fifo_cell5_sr_out[21] clk__L1_N0 n6584 DFFQX1TS
Xfifo_from_fir_fifo_cell5_register_sr_reg[20]
+ fifo_from_fir_fifo_cell5_sr_out[20] clk__L1_N0 n6585 DFFQX1TS
Xfifo_from_fir_fifo_cell5_register_sr_reg[19]
+ fifo_from_fir_fifo_cell5_sr_out[19] clk__L1_N0 n6586 DFFQX1TS
Xfifo_from_fir_fifo_cell5_register_sr_reg[18]
+ fifo_from_fir_fifo_cell5_sr_out[18] clk__L1_N0 n6587 DFFQX1TS
Xfifo_from_fir_fifo_cell5_register_sr_reg[17]
+ fifo_from_fir_fifo_cell5_sr_out[17] clk__L1_N0 n6588 DFFQX1TS
Xfifo_from_fir_fifo_cell5_register_sr_reg[16]
+ fifo_from_fir_fifo_cell5_sr_out[16] clk__L1_N0 n6589 DFFQX1TS
Xfifo_from_fir_fifo_cell5_register_sr_reg[15]
+ fifo_from_fir_fifo_cell5_sr_out[15] clk__L1_N0 n6590 DFFQX1TS
Xfifo_from_fir_fifo_cell5_register_sr_reg[14]
+ fifo_from_fir_fifo_cell5_sr_out[14] clk__L1_N0 n6591 DFFQX1TS
Xfifo_from_fir_fifo_cell5_register_sr_reg[13]
+ fifo_from_fir_fifo_cell5_sr_out[13] clk__L1_N0 n6592 DFFQX1TS
Xfifo_from_fir_fifo_cell5_register_sr_reg[12]
+ fifo_from_fir_fifo_cell5_sr_out[12] clk__L1_N0 n6593 DFFQX1TS
Xfifo_from_fir_fifo_cell5_register_sr_reg[11]
+ fifo_from_fir_fifo_cell5_sr_out[11] clk__L1_N0 n6594 DFFQX1TS
Xfifo_from_fir_fifo_cell5_register_sr_reg[10]
+ fifo_from_fir_fifo_cell5_sr_out[10] clk__L1_N0 n6595 DFFQX1TS
Xfifo_from_fir_fifo_cell5_register_sr_reg[9] fifo_from_fir_fifo_cell5_sr_out[9]
+ clk__L1_N0 n6596 DFFQX1TS
Xfifo_from_fir_fifo_cell5_register_sr_reg[8] fifo_from_fir_fifo_cell5_sr_out[8]
+ clk__L1_N0 n6597 DFFQX1TS
Xfifo_from_fir_fifo_cell5_register_sr_reg[7] fifo_from_fir_fifo_cell5_sr_out[7]
+ clk__L1_N0 n6598 DFFQX1TS
Xfifo_from_fir_fifo_cell5_register_sr_reg[6] fifo_from_fir_fifo_cell5_sr_out[6]
+ clk__L1_N0 n6599 DFFQX1TS
Xfifo_from_fir_fifo_cell5_register_sr_reg[5] fifo_from_fir_fifo_cell5_sr_out[5]
+ clk__L1_N0 n6600 DFFQX1TS
Xfifo_from_fir_fifo_cell5_register_sr_reg[4] fifo_from_fir_fifo_cell5_sr_out[4]
+ clk__L1_N0 n6601 DFFQX1TS
Xfifo_from_fir_fifo_cell5_register_sr_reg[3] fifo_from_fir_fifo_cell5_sr_out[3]
+ clk__L1_N0 n6602 DFFQX1TS
Xfifo_from_fir_fifo_cell5_register_sr_reg[2] fifo_from_fir_fifo_cell5_sr_out[2]
+ clk__L1_N0 n6603 DFFQX1TS
Xfifo_from_fir_fifo_cell5_register_sr_reg[1] fifo_from_fir_fifo_cell5_sr_out[1]
+ clk__L1_N0 n6604 DFFQX1TS
Xfifo_from_fir_fifo_cell5_register_sr_reg[0] fifo_from_fir_fifo_cell5_sr_out[0]
+ clk__L1_N0 n6605 DFFQX1TS
Xfifo_from_fir_fifo_cell6_register_sr_reg[31]
+ fifo_from_fir_fifo_cell6_sr_out[31] clk__L1_N0 n6540 DFFQX1TS
Xfifo_from_fir_fifo_cell6_register_sr_reg[30]
+ fifo_from_fir_fifo_cell6_sr_out[30] clk__L1_N0 n6541 DFFQX1TS
Xfifo_from_fir_fifo_cell6_register_sr_reg[29]
+ fifo_from_fir_fifo_cell6_sr_out[29] clk__L1_N0 n6542 DFFQX1TS
Xfifo_from_fir_fifo_cell6_register_sr_reg[28]
+ fifo_from_fir_fifo_cell6_sr_out[28] clk__L1_N0 n6543 DFFQX1TS
Xfifo_from_fir_fifo_cell6_register_sr_reg[27]
+ fifo_from_fir_fifo_cell6_sr_out[27] clk__L1_N0 n6544 DFFQX1TS
Xfifo_from_fir_fifo_cell6_register_sr_reg[26]
+ fifo_from_fir_fifo_cell6_sr_out[26] clk__L1_N0 n6545 DFFQX1TS
Xfifo_from_fir_fifo_cell6_register_sr_reg[25]
+ fifo_from_fir_fifo_cell6_sr_out[25] clk__L1_N0 n6546 DFFQX1TS
Xfifo_from_fir_fifo_cell6_register_sr_reg[24]
+ fifo_from_fir_fifo_cell6_sr_out[24] clk__L1_N0 n6547 DFFQX1TS
Xfifo_from_fir_fifo_cell6_register_sr_reg[23]
+ fifo_from_fir_fifo_cell6_sr_out[23] clk__L1_N0 n6548 DFFQX1TS
Xfifo_from_fir_fifo_cell6_register_sr_reg[22]
+ fifo_from_fir_fifo_cell6_sr_out[22] clk__L1_N0 n6549 DFFQX1TS
Xfifo_from_fir_fifo_cell6_register_sr_reg[21]
+ fifo_from_fir_fifo_cell6_sr_out[21] clk__L1_N0 n6550 DFFQX1TS
Xfifo_from_fir_fifo_cell6_register_sr_reg[20]
+ fifo_from_fir_fifo_cell6_sr_out[20] clk__L1_N0 n6551 DFFQX1TS
Xfifo_from_fir_fifo_cell6_register_sr_reg[19]
+ fifo_from_fir_fifo_cell6_sr_out[19] clk__L1_N0 n6552 DFFQX1TS
Xfifo_from_fir_fifo_cell6_register_sr_reg[18]
+ fifo_from_fir_fifo_cell6_sr_out[18] clk__L1_N0 n6553 DFFQX1TS
Xfifo_from_fir_fifo_cell6_register_sr_reg[17]
+ fifo_from_fir_fifo_cell6_sr_out[17] clk__L1_N0 n6554 DFFQX1TS
Xfifo_from_fir_fifo_cell6_register_sr_reg[16]
+ fifo_from_fir_fifo_cell6_sr_out[16] clk__L1_N0 n6555 DFFQX1TS
Xfifo_from_fir_fifo_cell6_register_sr_reg[15]
+ fifo_from_fir_fifo_cell6_sr_out[15] clk__L1_N0 n6556 DFFQX1TS
Xfifo_from_fir_fifo_cell6_register_sr_reg[14]
+ fifo_from_fir_fifo_cell6_sr_out[14] clk__L1_N0 n6557 DFFQX1TS
Xfifo_from_fir_fifo_cell6_register_sr_reg[13]
+ fifo_from_fir_fifo_cell6_sr_out[13] clk__L1_N0 n6558 DFFQX1TS
Xfifo_from_fir_fifo_cell6_register_sr_reg[12]
+ fifo_from_fir_fifo_cell6_sr_out[12] clk__L1_N0 n6559 DFFQX1TS
Xfifo_from_fir_fifo_cell6_register_sr_reg[11]
+ fifo_from_fir_fifo_cell6_sr_out[11] clk__L1_N0 n6560 DFFQX1TS
Xfifo_from_fir_fifo_cell6_register_sr_reg[10]
+ fifo_from_fir_fifo_cell6_sr_out[10] clk__L1_N0 n6561 DFFQX1TS
Xfifo_from_fir_fifo_cell6_register_sr_reg[9] fifo_from_fir_fifo_cell6_sr_out[9]
+ clk__L1_N0 n6562 DFFQX1TS
Xfifo_from_fir_fifo_cell6_register_sr_reg[8] fifo_from_fir_fifo_cell6_sr_out[8]
+ clk__L1_N0 n6563 DFFQX1TS
Xfifo_from_fir_fifo_cell6_register_sr_reg[7] fifo_from_fir_fifo_cell6_sr_out[7]
+ clk__L1_N0 n6564 DFFQX1TS
Xfifo_from_fir_fifo_cell6_register_sr_reg[6] fifo_from_fir_fifo_cell6_sr_out[6]
+ clk__L1_N0 n6565 DFFQX1TS
Xfifo_from_fir_fifo_cell6_register_sr_reg[5] fifo_from_fir_fifo_cell6_sr_out[5]
+ clk__L1_N0 n6566 DFFQX1TS
Xfifo_from_fir_fifo_cell6_register_sr_reg[4] fifo_from_fir_fifo_cell6_sr_out[4]
+ clk__L1_N0 n6567 DFFQX1TS
Xfifo_from_fir_fifo_cell6_register_sr_reg[3] fifo_from_fir_fifo_cell6_sr_out[3]
+ clk__L1_N0 n6568 DFFQX1TS
Xfifo_from_fir_fifo_cell6_register_sr_reg[2] fifo_from_fir_fifo_cell6_sr_out[2]
+ clk__L1_N0 n6569 DFFQX1TS
Xfifo_from_fir_fifo_cell6_register_sr_reg[1] fifo_from_fir_fifo_cell6_sr_out[1]
+ clk__L1_N0 n6570 DFFQX1TS
Xfifo_from_fir_fifo_cell6_register_sr_reg[0] fifo_from_fir_fifo_cell6_sr_out[0]
+ clk__L1_N0 n6571 DFFQX1TS
Xfifo_from_fir_fifo_cell7_register_sr_reg[31]
+ fifo_from_fir_fifo_cell7_sr_out[31] clk__L1_N0 n6506 DFFQX1TS
Xfifo_from_fir_fifo_cell7_register_sr_reg[30]
+ fifo_from_fir_fifo_cell7_sr_out[30] clk__L1_N0 n6507 DFFQX1TS
Xfifo_from_fir_fifo_cell7_register_sr_reg[29]
+ fifo_from_fir_fifo_cell7_sr_out[29] clk__L1_N0 n6508 DFFQX1TS
Xfifo_from_fir_fifo_cell7_register_sr_reg[28]
+ fifo_from_fir_fifo_cell7_sr_out[28] clk__L1_N0 n6509 DFFQX1TS
Xfifo_from_fir_fifo_cell7_register_sr_reg[27]
+ fifo_from_fir_fifo_cell7_sr_out[27] clk__L1_N0 n6510 DFFQX1TS
Xfifo_from_fir_fifo_cell7_register_sr_reg[26]
+ fifo_from_fir_fifo_cell7_sr_out[26] clk__L1_N0 n6511 DFFQX1TS
Xfifo_from_fir_fifo_cell7_register_sr_reg[25]
+ fifo_from_fir_fifo_cell7_sr_out[25] clk__L1_N0 n6512 DFFQX1TS
Xfifo_from_fir_fifo_cell7_register_sr_reg[24]
+ fifo_from_fir_fifo_cell7_sr_out[24] clk__L1_N0 n6513 DFFQX1TS
Xfifo_from_fir_fifo_cell7_register_sr_reg[23]
+ fifo_from_fir_fifo_cell7_sr_out[23] clk__L1_N0 n6514 DFFQX1TS
Xfifo_from_fir_fifo_cell7_register_sr_reg[22]
+ fifo_from_fir_fifo_cell7_sr_out[22] clk__L1_N0 n6515 DFFQX1TS
Xfifo_from_fir_fifo_cell7_register_sr_reg[21]
+ fifo_from_fir_fifo_cell7_sr_out[21] clk__L1_N0 n6516 DFFQX1TS
Xfifo_from_fir_fifo_cell7_register_sr_reg[20]
+ fifo_from_fir_fifo_cell7_sr_out[20] clk__L1_N0 n6517 DFFQX1TS
Xfifo_from_fir_fifo_cell7_register_sr_reg[19]
+ fifo_from_fir_fifo_cell7_sr_out[19] clk__L1_N0 n6518 DFFQX1TS
Xfifo_from_fir_fifo_cell7_register_sr_reg[18]
+ fifo_from_fir_fifo_cell7_sr_out[18] clk__L1_N0 n6519 DFFQX1TS
Xfifo_from_fir_fifo_cell7_register_sr_reg[17]
+ fifo_from_fir_fifo_cell7_sr_out[17] clk__L1_N0 n6520 DFFQX1TS
Xfifo_from_fir_fifo_cell7_register_sr_reg[16]
+ fifo_from_fir_fifo_cell7_sr_out[16] clk__L1_N0 n6521 DFFQX1TS
Xfifo_from_fir_fifo_cell7_register_sr_reg[15]
+ fifo_from_fir_fifo_cell7_sr_out[15] clk__L1_N0 n6522 DFFQX1TS
Xfifo_from_fir_fifo_cell7_register_sr_reg[14]
+ fifo_from_fir_fifo_cell7_sr_out[14] clk__L1_N0 n6523 DFFQX1TS
Xfifo_from_fir_fifo_cell7_register_sr_reg[13]
+ fifo_from_fir_fifo_cell7_sr_out[13] clk__L1_N0 n6524 DFFQX1TS
Xfifo_from_fir_fifo_cell7_register_sr_reg[12]
+ fifo_from_fir_fifo_cell7_sr_out[12] clk__L1_N0 n6525 DFFQX1TS
Xfifo_from_fir_fifo_cell7_register_sr_reg[11]
+ fifo_from_fir_fifo_cell7_sr_out[11] clk__L1_N0 n6526 DFFQX1TS
Xfifo_from_fir_fifo_cell7_register_sr_reg[10]
+ fifo_from_fir_fifo_cell7_sr_out[10] clk__L1_N0 n6527 DFFQX1TS
Xfifo_from_fir_fifo_cell7_register_sr_reg[9] fifo_from_fir_fifo_cell7_sr_out[9]
+ clk__L1_N0 n6528 DFFQX1TS
Xfifo_from_fir_fifo_cell7_register_sr_reg[8] fifo_from_fir_fifo_cell7_sr_out[8]
+ clk__L1_N0 n6529 DFFQX1TS
Xfifo_from_fir_fifo_cell7_register_sr_reg[7] fifo_from_fir_fifo_cell7_sr_out[7]
+ clk__L1_N0 n6530 DFFQX1TS
Xfifo_from_fir_fifo_cell7_register_sr_reg[6] fifo_from_fir_fifo_cell7_sr_out[6]
+ clk__L1_N0 n6531 DFFQX1TS
Xfifo_from_fir_fifo_cell7_register_sr_reg[5] fifo_from_fir_fifo_cell7_sr_out[5]
+ clk__L1_N0 n6532 DFFQX1TS
Xfifo_from_fir_fifo_cell7_register_sr_reg[4] fifo_from_fir_fifo_cell7_sr_out[4]
+ clk__L1_N0 n6533 DFFQX1TS
Xfifo_from_fir_fifo_cell7_register_sr_reg[3] fifo_from_fir_fifo_cell7_sr_out[3]
+ clk__L1_N0 n6534 DFFQX1TS
Xfifo_from_fir_fifo_cell7_register_sr_reg[2] fifo_from_fir_fifo_cell7_sr_out[2]
+ clk__L1_N0 n6535 DFFQX1TS
Xfifo_from_fir_fifo_cell7_register_sr_reg[1] fifo_from_fir_fifo_cell7_sr_out[1]
+ clk__L1_N0 n6536 DFFQX1TS
Xfifo_from_fir_fifo_cell7_register_sr_reg[0] fifo_from_fir_fifo_cell7_sr_out[0]
+ clk__L1_N0 n6537 DFFQX1TS
Xfifo_from_fir_fifo_cell8_register_sr_reg[31]
+ fifo_from_fir_fifo_cell8_sr_out[31] clk__L1_N0 n6472 DFFQX1TS
Xfifo_from_fir_fifo_cell8_register_sr_reg[30]
+ fifo_from_fir_fifo_cell8_sr_out[30] clk__L1_N0 n6473 DFFQX1TS
Xfifo_from_fir_fifo_cell8_register_sr_reg[29]
+ fifo_from_fir_fifo_cell8_sr_out[29] clk__L1_N0 n6474 DFFQX1TS
Xfifo_from_fir_fifo_cell8_register_sr_reg[28]
+ fifo_from_fir_fifo_cell8_sr_out[28] clk__L1_N0 n6475 DFFQX1TS
Xfifo_from_fir_fifo_cell8_register_sr_reg[27]
+ fifo_from_fir_fifo_cell8_sr_out[27] clk__L1_N0 n6476 DFFQX1TS
Xfifo_from_fir_fifo_cell8_register_sr_reg[26]
+ fifo_from_fir_fifo_cell8_sr_out[26] clk__L1_N0 n6477 DFFQX1TS
Xfifo_from_fir_fifo_cell8_register_sr_reg[25]
+ fifo_from_fir_fifo_cell8_sr_out[25] clk__L1_N0 n6478 DFFQX1TS
Xfifo_from_fir_fifo_cell8_register_sr_reg[24]
+ fifo_from_fir_fifo_cell8_sr_out[24] clk__L1_N0 n6479 DFFQX1TS
Xfifo_from_fir_fifo_cell8_register_sr_reg[23]
+ fifo_from_fir_fifo_cell8_sr_out[23] clk__L1_N0 n6480 DFFQX1TS
Xfifo_from_fir_fifo_cell8_register_sr_reg[22]
+ fifo_from_fir_fifo_cell8_sr_out[22] clk__L1_N0 n6481 DFFQX1TS
Xfifo_from_fir_fifo_cell8_register_sr_reg[21]
+ fifo_from_fir_fifo_cell8_sr_out[21] clk__L1_N0 n6482 DFFQX1TS
Xfifo_from_fir_fifo_cell8_register_sr_reg[20]
+ fifo_from_fir_fifo_cell8_sr_out[20] clk__L1_N0 n6483 DFFQX1TS
Xfifo_from_fir_fifo_cell8_register_sr_reg[19]
+ fifo_from_fir_fifo_cell8_sr_out[19] clk__L1_N0 n6484 DFFQX1TS
Xfifo_from_fir_fifo_cell8_register_sr_reg[18]
+ fifo_from_fir_fifo_cell8_sr_out[18] clk__L1_N0 n6485 DFFQX1TS
Xfifo_from_fir_fifo_cell8_register_sr_reg[17]
+ fifo_from_fir_fifo_cell8_sr_out[17] clk__L1_N0 n6486 DFFQX1TS
Xfifo_from_fir_fifo_cell8_register_sr_reg[16]
+ fifo_from_fir_fifo_cell8_sr_out[16] clk__L1_N0 n6487 DFFQX1TS
Xfifo_from_fir_fifo_cell8_register_sr_reg[15]
+ fifo_from_fir_fifo_cell8_sr_out[15] clk__L1_N0 n6488 DFFQX1TS
Xfifo_from_fir_fifo_cell8_register_sr_reg[14]
+ fifo_from_fir_fifo_cell8_sr_out[14] clk__L1_N0 n6489 DFFQX1TS
Xfifo_from_fir_fifo_cell8_register_sr_reg[13]
+ fifo_from_fir_fifo_cell8_sr_out[13] clk__L1_N0 n6490 DFFQX1TS
Xfifo_from_fir_fifo_cell8_register_sr_reg[12]
+ fifo_from_fir_fifo_cell8_sr_out[12] clk__L1_N0 n6491 DFFQX1TS
Xfifo_from_fir_fifo_cell8_register_sr_reg[11]
+ fifo_from_fir_fifo_cell8_sr_out[11] clk__L1_N0 n6492 DFFQX1TS
Xfifo_from_fir_fifo_cell8_register_sr_reg[10]
+ fifo_from_fir_fifo_cell8_sr_out[10] clk__L1_N0 n6493 DFFQX1TS
Xfifo_from_fir_fifo_cell8_register_sr_reg[9] fifo_from_fir_fifo_cell8_sr_out[9]
+ clk__L1_N0 n6494 DFFQX1TS
Xfifo_from_fir_fifo_cell8_register_sr_reg[8] fifo_from_fir_fifo_cell8_sr_out[8]
+ clk__L1_N0 n6495 DFFQX1TS
Xfifo_from_fir_fifo_cell8_register_sr_reg[7] fifo_from_fir_fifo_cell8_sr_out[7]
+ clk__L1_N0 n6496 DFFQX1TS
Xfifo_from_fir_fifo_cell8_register_sr_reg[6] fifo_from_fir_fifo_cell8_sr_out[6]
+ clk__L1_N0 n6497 DFFQX1TS
Xfifo_from_fir_fifo_cell8_register_sr_reg[5] fifo_from_fir_fifo_cell8_sr_out[5]
+ clk__L1_N0 n6498 DFFQX1TS
Xfifo_from_fir_fifo_cell8_register_sr_reg[4] fifo_from_fir_fifo_cell8_sr_out[4]
+ clk__L1_N0 n6499 DFFQX1TS
Xfifo_from_fir_fifo_cell8_register_sr_reg[3] fifo_from_fir_fifo_cell8_sr_out[3]
+ clk__L1_N0 n6500 DFFQX1TS
Xfifo_from_fir_fifo_cell8_register_sr_reg[2] fifo_from_fir_fifo_cell8_sr_out[2]
+ clk__L1_N0 n6501 DFFQX1TS
Xfifo_from_fir_fifo_cell8_register_sr_reg[1] fifo_from_fir_fifo_cell8_sr_out[1]
+ clk__L1_N0 n6502 DFFQX1TS
Xfifo_from_fir_fifo_cell8_register_sr_reg[0] fifo_from_fir_fifo_cell8_sr_out[0]
+ clk__L1_N0 n6503 DFFQX1TS
Xfifo_from_fir_fifo_cell9_register_sr_reg[31]
+ fifo_from_fir_fifo_cell9_sr_out[31] clk__L1_N0 n6438 DFFQX1TS
Xfifo_from_fir_fifo_cell9_register_sr_reg[30]
+ fifo_from_fir_fifo_cell9_sr_out[30] clk__L1_N0 n6439 DFFQX1TS
Xfifo_from_fir_fifo_cell9_register_sr_reg[29]
+ fifo_from_fir_fifo_cell9_sr_out[29] clk__L1_N0 n6440 DFFQX1TS
Xfifo_from_fir_fifo_cell9_register_sr_reg[28]
+ fifo_from_fir_fifo_cell9_sr_out[28] clk__L1_N0 n6441 DFFQX1TS
Xfifo_from_fir_fifo_cell9_register_sr_reg[27]
+ fifo_from_fir_fifo_cell9_sr_out[27] clk__L1_N0 n6442 DFFQX1TS
Xfifo_from_fir_fifo_cell9_register_sr_reg[26]
+ fifo_from_fir_fifo_cell9_sr_out[26] clk__L1_N0 n6443 DFFQX1TS
Xfifo_from_fir_fifo_cell9_register_sr_reg[25]
+ fifo_from_fir_fifo_cell9_sr_out[25] clk__L1_N0 n6444 DFFQX1TS
Xfifo_from_fir_fifo_cell9_register_sr_reg[24]
+ fifo_from_fir_fifo_cell9_sr_out[24] clk__L1_N0 n6445 DFFQX1TS
Xfifo_from_fir_fifo_cell9_register_sr_reg[23]
+ fifo_from_fir_fifo_cell9_sr_out[23] clk__L1_N0 n6446 DFFQX1TS
Xfifo_from_fir_fifo_cell9_register_sr_reg[22]
+ fifo_from_fir_fifo_cell9_sr_out[22] clk__L1_N0 n6447 DFFQX1TS
Xfifo_from_fir_fifo_cell9_register_sr_reg[21]
+ fifo_from_fir_fifo_cell9_sr_out[21] clk__L1_N0 n6448 DFFQX1TS
Xfifo_from_fir_fifo_cell9_register_sr_reg[20]
+ fifo_from_fir_fifo_cell9_sr_out[20] clk__L1_N0 n6449 DFFQX1TS
Xfifo_from_fir_fifo_cell9_register_sr_reg[19]
+ fifo_from_fir_fifo_cell9_sr_out[19] clk__L1_N0 n6450 DFFQX1TS
Xfifo_from_fir_fifo_cell9_register_sr_reg[18]
+ fifo_from_fir_fifo_cell9_sr_out[18] clk__L1_N0 n6451 DFFQX1TS
Xfifo_from_fir_fifo_cell9_register_sr_reg[17]
+ fifo_from_fir_fifo_cell9_sr_out[17] clk__L1_N0 n6452 DFFQX1TS
Xfifo_from_fir_fifo_cell9_register_sr_reg[16]
+ fifo_from_fir_fifo_cell9_sr_out[16] clk__L1_N0 n6453 DFFQX1TS
Xfifo_from_fir_fifo_cell9_register_sr_reg[15]
+ fifo_from_fir_fifo_cell9_sr_out[15] clk__L1_N0 n6454 DFFQX1TS
Xfifo_from_fir_fifo_cell9_register_sr_reg[14]
+ fifo_from_fir_fifo_cell9_sr_out[14] clk__L1_N0 n6455 DFFQX1TS
Xfifo_from_fir_fifo_cell9_register_sr_reg[13]
+ fifo_from_fir_fifo_cell9_sr_out[13] clk__L1_N0 n6456 DFFQX1TS
Xfifo_from_fir_fifo_cell9_register_sr_reg[12]
+ fifo_from_fir_fifo_cell9_sr_out[12] clk__L1_N0 n6457 DFFQX1TS
Xfifo_from_fir_fifo_cell9_register_sr_reg[11]
+ fifo_from_fir_fifo_cell9_sr_out[11] clk__L1_N0 n6458 DFFQX1TS
Xfifo_from_fir_fifo_cell9_register_sr_reg[10]
+ fifo_from_fir_fifo_cell9_sr_out[10] clk__L1_N0 n6459 DFFQX1TS
Xfifo_from_fir_fifo_cell9_register_sr_reg[9] fifo_from_fir_fifo_cell9_sr_out[9]
+ clk__L1_N0 n6460 DFFQX1TS
Xfifo_from_fir_fifo_cell9_register_sr_reg[8] fifo_from_fir_fifo_cell9_sr_out[8]
+ clk__L1_N0 n6461 DFFQX1TS
Xfifo_from_fir_fifo_cell9_register_sr_reg[7] fifo_from_fir_fifo_cell9_sr_out[7]
+ clk__L1_N0 n6462 DFFQX1TS
Xfifo_from_fir_fifo_cell9_register_sr_reg[6] fifo_from_fir_fifo_cell9_sr_out[6]
+ clk__L1_N0 n6463 DFFQX1TS
Xfifo_from_fir_fifo_cell9_register_sr_reg[5] fifo_from_fir_fifo_cell9_sr_out[5]
+ clk__L1_N0 n6464 DFFQX1TS
Xfifo_from_fir_fifo_cell9_register_sr_reg[4] fifo_from_fir_fifo_cell9_sr_out[4]
+ clk__L1_N0 n6465 DFFQX1TS
Xfifo_from_fir_fifo_cell9_register_sr_reg[3] fifo_from_fir_fifo_cell9_sr_out[3]
+ clk__L1_N0 n6466 DFFQX1TS
Xfifo_from_fir_fifo_cell9_register_sr_reg[2] fifo_from_fir_fifo_cell9_sr_out[2]
+ clk__L1_N0 n6467 DFFQX1TS
Xfifo_from_fir_fifo_cell9_register_sr_reg[1] fifo_from_fir_fifo_cell9_sr_out[1]
+ clk__L1_N0 n6468 DFFQX1TS
Xfifo_from_fir_fifo_cell9_register_sr_reg[0] fifo_from_fir_fifo_cell9_sr_out[0]
+ clk__L1_N0 n6469 DFFQX1TS
Xfifo_from_fir_fifo_cell10_register_sr_reg[31]
+ fifo_from_fir_fifo_cell10_sr_out[31] clk__L1_N0 n6404 DFFQX1TS
Xfifo_from_fir_fifo_cell10_register_sr_reg[30]
+ fifo_from_fir_fifo_cell10_sr_out[30] clk__L1_N0 n6405 DFFQX1TS
Xfifo_from_fir_fifo_cell10_register_sr_reg[29]
+ fifo_from_fir_fifo_cell10_sr_out[29] clk__L1_N0 n6406 DFFQX1TS
Xfifo_from_fir_fifo_cell10_register_sr_reg[28]
+ fifo_from_fir_fifo_cell10_sr_out[28] clk__L1_N0 n6407 DFFQX1TS
Xfifo_from_fir_fifo_cell10_register_sr_reg[27]
+ fifo_from_fir_fifo_cell10_sr_out[27] clk__L1_N0 n6408 DFFQX1TS
Xfifo_from_fir_fifo_cell10_register_sr_reg[26]
+ fifo_from_fir_fifo_cell10_sr_out[26] clk__L1_N0 n6409 DFFQX1TS
Xfifo_from_fir_fifo_cell10_register_sr_reg[25]
+ fifo_from_fir_fifo_cell10_sr_out[25] clk__L1_N0 n6410 DFFQX1TS
Xfifo_from_fir_fifo_cell10_register_sr_reg[24]
+ fifo_from_fir_fifo_cell10_sr_out[24] clk__L1_N0 n6411 DFFQX1TS
Xfifo_from_fir_fifo_cell10_register_sr_reg[23]
+ fifo_from_fir_fifo_cell10_sr_out[23] clk__L1_N0 n6412 DFFQX1TS
Xfifo_from_fir_fifo_cell10_register_sr_reg[22]
+ fifo_from_fir_fifo_cell10_sr_out[22] clk__L1_N0 n6413 DFFQX1TS
Xfifo_from_fir_fifo_cell10_register_sr_reg[21]
+ fifo_from_fir_fifo_cell10_sr_out[21] clk__L1_N0 n6414 DFFQX1TS
Xfifo_from_fir_fifo_cell10_register_sr_reg[20]
+ fifo_from_fir_fifo_cell10_sr_out[20] clk__L1_N0 n6415 DFFQX1TS
Xfifo_from_fir_fifo_cell10_register_sr_reg[19]
+ fifo_from_fir_fifo_cell10_sr_out[19] clk__L1_N0 n6416 DFFQX1TS
Xfifo_from_fir_fifo_cell10_register_sr_reg[18]
+ fifo_from_fir_fifo_cell10_sr_out[18] clk__L1_N0 n6417 DFFQX1TS
Xfifo_from_fir_fifo_cell10_register_sr_reg[17]
+ fifo_from_fir_fifo_cell10_sr_out[17] clk__L1_N0 n6418 DFFQX1TS
Xfifo_from_fir_fifo_cell10_register_sr_reg[16]
+ fifo_from_fir_fifo_cell10_sr_out[16] clk__L1_N0 n6419 DFFQX1TS
Xfifo_from_fir_fifo_cell10_register_sr_reg[15]
+ fifo_from_fir_fifo_cell10_sr_out[15] clk__L1_N0 n6420 DFFQX1TS
Xfifo_from_fir_fifo_cell10_register_sr_reg[14]
+ fifo_from_fir_fifo_cell10_sr_out[14] clk__L1_N0 n6421 DFFQX1TS
Xfifo_from_fir_fifo_cell10_register_sr_reg[13]
+ fifo_from_fir_fifo_cell10_sr_out[13] clk__L1_N0 n6422 DFFQX1TS
Xfifo_from_fir_fifo_cell10_register_sr_reg[12]
+ fifo_from_fir_fifo_cell10_sr_out[12] clk__L1_N0 n6423 DFFQX1TS
Xfifo_from_fir_fifo_cell10_register_sr_reg[11]
+ fifo_from_fir_fifo_cell10_sr_out[11] clk__L1_N0 n6424 DFFQX1TS
Xfifo_from_fir_fifo_cell10_register_sr_reg[10]
+ fifo_from_fir_fifo_cell10_sr_out[10] clk__L1_N0 n6425 DFFQX1TS
Xfifo_from_fir_fifo_cell10_register_sr_reg[9]
+ fifo_from_fir_fifo_cell10_sr_out[9] clk__L1_N0 n6426 DFFQX1TS
Xfifo_from_fir_fifo_cell10_register_sr_reg[8]
+ fifo_from_fir_fifo_cell10_sr_out[8] clk__L1_N0 n6427 DFFQX1TS
Xfifo_from_fir_fifo_cell10_register_sr_reg[7]
+ fifo_from_fir_fifo_cell10_sr_out[7] clk__L1_N0 n6428 DFFQX1TS
Xfifo_from_fir_fifo_cell10_register_sr_reg[6]
+ fifo_from_fir_fifo_cell10_sr_out[6] clk__L1_N0 n6429 DFFQX1TS
Xfifo_from_fir_fifo_cell10_register_sr_reg[5]
+ fifo_from_fir_fifo_cell10_sr_out[5] clk__L1_N0 n6430 DFFQX1TS
Xfifo_from_fir_fifo_cell10_register_sr_reg[4]
+ fifo_from_fir_fifo_cell10_sr_out[4] clk__L1_N0 n6431 DFFQX1TS
Xfifo_from_fir_fifo_cell10_register_sr_reg[3]
+ fifo_from_fir_fifo_cell10_sr_out[3] clk__L1_N0 n6432 DFFQX1TS
Xfifo_from_fir_fifo_cell10_register_sr_reg[2]
+ fifo_from_fir_fifo_cell10_sr_out[2] clk__L1_N0 n6433 DFFQX1TS
Xfifo_from_fir_fifo_cell10_register_sr_reg[1]
+ fifo_from_fir_fifo_cell10_sr_out[1] clk__L1_N0 n6434 DFFQX1TS
Xfifo_from_fir_fifo_cell10_register_sr_reg[0]
+ fifo_from_fir_fifo_cell10_sr_out[0] clk__L1_N0 n6435 DFFQX1TS
Xfifo_from_fir_fifo_cell11_register_sr_reg[31]
+ fifo_from_fir_fifo_cell11_sr_out[31] clk__L1_N0 n6370 DFFQX1TS
Xfifo_from_fir_fifo_cell11_register_sr_reg[30]
+ fifo_from_fir_fifo_cell11_sr_out[30] clk__L1_N0 n6371 DFFQX1TS
Xfifo_from_fir_fifo_cell11_register_sr_reg[29]
+ fifo_from_fir_fifo_cell11_sr_out[29] clk__L1_N0 n6372 DFFQX1TS
Xfifo_from_fir_fifo_cell11_register_sr_reg[28]
+ fifo_from_fir_fifo_cell11_sr_out[28] clk__L1_N0 n6373 DFFQX1TS
Xfifo_from_fir_fifo_cell11_register_sr_reg[27]
+ fifo_from_fir_fifo_cell11_sr_out[27] clk__L1_N0 n6374 DFFQX1TS
Xfifo_from_fir_fifo_cell11_register_sr_reg[26]
+ fifo_from_fir_fifo_cell11_sr_out[26] clk__L1_N0 n6375 DFFQX1TS
Xfifo_from_fir_fifo_cell11_register_sr_reg[25]
+ fifo_from_fir_fifo_cell11_sr_out[25] clk__L1_N0 n6376 DFFQX1TS
Xfifo_from_fir_fifo_cell11_register_sr_reg[24]
+ fifo_from_fir_fifo_cell11_sr_out[24] clk__L1_N0 n6377 DFFQX1TS
Xfifo_from_fir_fifo_cell11_register_sr_reg[23]
+ fifo_from_fir_fifo_cell11_sr_out[23] clk__L1_N0 n6378 DFFQX1TS
Xfifo_from_fir_fifo_cell11_register_sr_reg[22]
+ fifo_from_fir_fifo_cell11_sr_out[22] clk__L1_N0 n6379 DFFQX1TS
Xfifo_from_fir_fifo_cell11_register_sr_reg[21]
+ fifo_from_fir_fifo_cell11_sr_out[21] clk__L1_N0 n6380 DFFQX1TS
Xfifo_from_fir_fifo_cell11_register_sr_reg[20]
+ fifo_from_fir_fifo_cell11_sr_out[20] clk__L1_N0 n6381 DFFQX1TS
Xfifo_from_fir_fifo_cell11_register_sr_reg[19]
+ fifo_from_fir_fifo_cell11_sr_out[19] clk__L1_N0 n6382 DFFQX1TS
Xfifo_from_fir_fifo_cell11_register_sr_reg[18]
+ fifo_from_fir_fifo_cell11_sr_out[18] clk__L1_N0 n6383 DFFQX1TS
Xfifo_from_fir_fifo_cell11_register_sr_reg[17]
+ fifo_from_fir_fifo_cell11_sr_out[17] clk__L1_N0 n6384 DFFQX1TS
Xfifo_from_fir_fifo_cell11_register_sr_reg[16]
+ fifo_from_fir_fifo_cell11_sr_out[16] clk__L1_N0 n6385 DFFQX1TS
Xfifo_from_fir_fifo_cell11_register_sr_reg[15]
+ fifo_from_fir_fifo_cell11_sr_out[15] clk__L1_N0 n6386 DFFQX1TS
Xfifo_from_fir_fifo_cell11_register_sr_reg[14]
+ fifo_from_fir_fifo_cell11_sr_out[14] clk__L1_N0 n6387 DFFQX1TS
Xfifo_from_fir_fifo_cell11_register_sr_reg[13]
+ fifo_from_fir_fifo_cell11_sr_out[13] clk__L1_N0 n6388 DFFQX1TS
Xfifo_from_fir_fifo_cell11_register_sr_reg[12]
+ fifo_from_fir_fifo_cell11_sr_out[12] clk__L1_N0 n6389 DFFQX1TS
Xfifo_from_fir_fifo_cell11_register_sr_reg[11]
+ fifo_from_fir_fifo_cell11_sr_out[11] clk__L1_N0 n6390 DFFQX1TS
Xfifo_from_fir_fifo_cell11_register_sr_reg[10]
+ fifo_from_fir_fifo_cell11_sr_out[10] clk__L1_N0 n6391 DFFQX1TS
Xfifo_from_fir_fifo_cell11_register_sr_reg[9]
+ fifo_from_fir_fifo_cell11_sr_out[9] clk__L1_N0 n6392 DFFQX1TS
Xfifo_from_fir_fifo_cell11_register_sr_reg[8]
+ fifo_from_fir_fifo_cell11_sr_out[8] clk__L1_N0 n6393 DFFQX1TS
Xfifo_from_fir_fifo_cell11_register_sr_reg[7]
+ fifo_from_fir_fifo_cell11_sr_out[7] clk__L1_N0 n6394 DFFQX1TS
Xfifo_from_fir_fifo_cell11_register_sr_reg[6]
+ fifo_from_fir_fifo_cell11_sr_out[6] clk__L1_N0 n6395 DFFQX1TS
Xfifo_from_fir_fifo_cell11_register_sr_reg[5]
+ fifo_from_fir_fifo_cell11_sr_out[5] clk__L1_N0 n6396 DFFQX1TS
Xfifo_from_fir_fifo_cell11_register_sr_reg[4]
+ fifo_from_fir_fifo_cell11_sr_out[4] clk__L1_N0 n6397 DFFQX1TS
Xfifo_from_fir_fifo_cell11_register_sr_reg[3]
+ fifo_from_fir_fifo_cell11_sr_out[3] clk__L1_N0 n6398 DFFQX1TS
Xfifo_from_fir_fifo_cell11_register_sr_reg[2]
+ fifo_from_fir_fifo_cell11_sr_out[2] clk__L1_N0 n6399 DFFQX1TS
Xfifo_from_fir_fifo_cell11_register_sr_reg[1]
+ fifo_from_fir_fifo_cell11_sr_out[1] clk__L1_N0 n6400 DFFQX1TS
Xfifo_from_fir_fifo_cell11_register_sr_reg[0]
+ fifo_from_fir_fifo_cell11_sr_out[0] clk__L1_N0 n6401 DFFQX1TS
Xfifo_from_fir_fifo_cell12_register_sr_reg[31]
+ fifo_from_fir_fifo_cell12_sr_out[31] clk__L1_N0 n6336 DFFQX1TS
Xfifo_from_fir_fifo_cell12_register_sr_reg[30]
+ fifo_from_fir_fifo_cell12_sr_out[30] clk__L1_N0 n6337 DFFQX1TS
Xfifo_from_fir_fifo_cell12_register_sr_reg[29]
+ fifo_from_fir_fifo_cell12_sr_out[29] clk__L1_N0 n6338 DFFQX1TS
Xfifo_from_fir_fifo_cell12_register_sr_reg[28]
+ fifo_from_fir_fifo_cell12_sr_out[28] clk__L1_N0 n6339 DFFQX1TS
Xfifo_from_fir_fifo_cell12_register_sr_reg[27]
+ fifo_from_fir_fifo_cell12_sr_out[27] clk__L1_N0 n6340 DFFQX1TS
Xfifo_from_fir_fifo_cell12_register_sr_reg[26]
+ fifo_from_fir_fifo_cell12_sr_out[26] clk__L1_N0 n6341 DFFQX1TS
Xfifo_from_fir_fifo_cell12_register_sr_reg[25]
+ fifo_from_fir_fifo_cell12_sr_out[25] clk__L1_N0 n6342 DFFQX1TS
Xfifo_from_fir_fifo_cell12_register_sr_reg[24]
+ fifo_from_fir_fifo_cell12_sr_out[24] clk__L1_N0 n6343 DFFQX1TS
Xfifo_from_fir_fifo_cell12_register_sr_reg[23]
+ fifo_from_fir_fifo_cell12_sr_out[23] clk__L1_N0 n6344 DFFQX1TS
Xfifo_from_fir_fifo_cell12_register_sr_reg[22]
+ fifo_from_fir_fifo_cell12_sr_out[22] clk__L1_N0 n6345 DFFQX1TS
Xfifo_from_fir_fifo_cell12_register_sr_reg[21]
+ fifo_from_fir_fifo_cell12_sr_out[21] clk__L1_N0 n6346 DFFQX1TS
Xfifo_from_fir_fifo_cell12_register_sr_reg[20]
+ fifo_from_fir_fifo_cell12_sr_out[20] clk__L1_N0 n6347 DFFQX1TS
Xfifo_from_fir_fifo_cell12_register_sr_reg[19]
+ fifo_from_fir_fifo_cell12_sr_out[19] clk__L1_N0 n6348 DFFQX1TS
Xfifo_from_fir_fifo_cell12_register_sr_reg[18]
+ fifo_from_fir_fifo_cell12_sr_out[18] clk__L1_N0 n6349 DFFQX1TS
Xfifo_from_fir_fifo_cell12_register_sr_reg[17]
+ fifo_from_fir_fifo_cell12_sr_out[17] clk__L1_N0 n6350 DFFQX1TS
Xfifo_from_fir_fifo_cell12_register_sr_reg[16]
+ fifo_from_fir_fifo_cell12_sr_out[16] clk__L1_N0 n6351 DFFQX1TS
Xfifo_from_fir_fifo_cell12_register_sr_reg[15]
+ fifo_from_fir_fifo_cell12_sr_out[15] clk__L1_N0 n6352 DFFQX1TS
Xfifo_from_fir_fifo_cell12_register_sr_reg[14]
+ fifo_from_fir_fifo_cell12_sr_out[14] clk__L1_N0 n6353 DFFQX1TS
Xfifo_from_fir_fifo_cell12_register_sr_reg[13]
+ fifo_from_fir_fifo_cell12_sr_out[13] clk__L1_N0 n6354 DFFQX1TS
Xfifo_from_fir_fifo_cell12_register_sr_reg[12]
+ fifo_from_fir_fifo_cell12_sr_out[12] clk__L1_N0 n6355 DFFQX1TS
Xfifo_from_fir_fifo_cell12_register_sr_reg[11]
+ fifo_from_fir_fifo_cell12_sr_out[11] clk__L1_N0 n6356 DFFQX1TS
Xfifo_from_fir_fifo_cell12_register_sr_reg[10]
+ fifo_from_fir_fifo_cell12_sr_out[10] clk__L1_N0 n6357 DFFQX1TS
Xfifo_from_fir_fifo_cell12_register_sr_reg[9]
+ fifo_from_fir_fifo_cell12_sr_out[9] clk__L1_N0 n6358 DFFQX1TS
Xfifo_from_fir_fifo_cell12_register_sr_reg[8]
+ fifo_from_fir_fifo_cell12_sr_out[8] clk__L1_N0 n6359 DFFQX1TS
Xfifo_from_fir_fifo_cell12_register_sr_reg[7]
+ fifo_from_fir_fifo_cell12_sr_out[7] clk__L1_N0 n6360 DFFQX1TS
Xfifo_from_fir_fifo_cell12_register_sr_reg[6]
+ fifo_from_fir_fifo_cell12_sr_out[6] clk__L1_N0 n6361 DFFQX1TS
Xfifo_from_fir_fifo_cell12_register_sr_reg[5]
+ fifo_from_fir_fifo_cell12_sr_out[5] clk__L1_N0 n6362 DFFQX1TS
Xfifo_from_fir_fifo_cell12_register_sr_reg[4]
+ fifo_from_fir_fifo_cell12_sr_out[4] clk__L1_N0 n6363 DFFQX1TS
Xfifo_from_fir_fifo_cell12_register_sr_reg[3]
+ fifo_from_fir_fifo_cell12_sr_out[3] clk__L1_N0 n6364 DFFQX1TS
Xfifo_from_fir_fifo_cell12_register_sr_reg[2]
+ fifo_from_fir_fifo_cell12_sr_out[2] clk__L1_N0 n6365 DFFQX1TS
Xfifo_from_fir_fifo_cell12_register_sr_reg[1]
+ fifo_from_fir_fifo_cell12_sr_out[1] clk__L1_N0 n6366 DFFQX1TS
Xfifo_from_fir_fifo_cell12_register_sr_reg[0]
+ fifo_from_fir_fifo_cell12_sr_out[0] clk__L1_N0 n6367 DFFQX1TS
Xfifo_from_fir_fifo_cell13_register_sr_reg[31]
+ fifo_from_fir_fifo_cell13_sr_out[31] clk__L1_N0 n6302 DFFQX1TS
Xfifo_from_fir_fifo_cell13_register_sr_reg[30]
+ fifo_from_fir_fifo_cell13_sr_out[30] clk__L1_N0 n6303 DFFQX1TS
Xfifo_from_fir_fifo_cell13_register_sr_reg[29]
+ fifo_from_fir_fifo_cell13_sr_out[29] clk__L1_N0 n6304 DFFQX1TS
Xfifo_from_fir_fifo_cell13_register_sr_reg[28]
+ fifo_from_fir_fifo_cell13_sr_out[28] clk__L1_N0 n6305 DFFQX1TS
Xfifo_from_fir_fifo_cell13_register_sr_reg[27]
+ fifo_from_fir_fifo_cell13_sr_out[27] clk__L1_N0 n6306 DFFQX1TS
Xfifo_from_fir_fifo_cell13_register_sr_reg[26]
+ fifo_from_fir_fifo_cell13_sr_out[26] clk__L1_N0 n6307 DFFQX1TS
Xfifo_from_fir_fifo_cell13_register_sr_reg[25]
+ fifo_from_fir_fifo_cell13_sr_out[25] clk__L1_N0 n6308 DFFQX1TS
Xfifo_from_fir_fifo_cell13_register_sr_reg[24]
+ fifo_from_fir_fifo_cell13_sr_out[24] clk__L1_N0 n6309 DFFQX1TS
Xfifo_from_fir_fifo_cell13_register_sr_reg[23]
+ fifo_from_fir_fifo_cell13_sr_out[23] clk__L1_N0 n6310 DFFQX1TS
Xfifo_from_fir_fifo_cell13_register_sr_reg[22]
+ fifo_from_fir_fifo_cell13_sr_out[22] clk__L1_N0 n6311 DFFQX1TS
Xfifo_from_fir_fifo_cell13_register_sr_reg[21]
+ fifo_from_fir_fifo_cell13_sr_out[21] clk__L1_N0 n6312 DFFQX1TS
Xfifo_from_fir_fifo_cell13_register_sr_reg[20]
+ fifo_from_fir_fifo_cell13_sr_out[20] clk__L1_N0 n6313 DFFQX1TS
Xfifo_from_fir_fifo_cell13_register_sr_reg[19]
+ fifo_from_fir_fifo_cell13_sr_out[19] clk__L1_N0 n6314 DFFQX1TS
Xfifo_from_fir_fifo_cell13_register_sr_reg[18]
+ fifo_from_fir_fifo_cell13_sr_out[18] clk__L1_N0 n6315 DFFQX1TS
Xfifo_from_fir_fifo_cell13_register_sr_reg[17]
+ fifo_from_fir_fifo_cell13_sr_out[17] clk__L1_N0 n6316 DFFQX1TS
Xfifo_from_fir_fifo_cell13_register_sr_reg[16]
+ fifo_from_fir_fifo_cell13_sr_out[16] clk__L1_N0 n6317 DFFQX1TS
Xfifo_from_fir_fifo_cell13_register_sr_reg[15]
+ fifo_from_fir_fifo_cell13_sr_out[15] clk__L1_N0 n6318 DFFQX1TS
Xfifo_from_fir_fifo_cell13_register_sr_reg[14]
+ fifo_from_fir_fifo_cell13_sr_out[14] clk__L1_N0 n6319 DFFQX1TS
Xfifo_from_fir_fifo_cell13_register_sr_reg[13]
+ fifo_from_fir_fifo_cell13_sr_out[13] clk__L1_N0 n6320 DFFQX1TS
Xfifo_from_fir_fifo_cell13_register_sr_reg[12]
+ fifo_from_fir_fifo_cell13_sr_out[12] clk__L1_N0 n6321 DFFQX1TS
Xfifo_from_fir_fifo_cell13_register_sr_reg[11]
+ fifo_from_fir_fifo_cell13_sr_out[11] clk__L1_N0 n6322 DFFQX1TS
Xfifo_from_fir_fifo_cell13_register_sr_reg[10]
+ fifo_from_fir_fifo_cell13_sr_out[10] clk__L1_N0 n6323 DFFQX1TS
Xfifo_from_fir_fifo_cell13_register_sr_reg[9]
+ fifo_from_fir_fifo_cell13_sr_out[9] clk__L1_N0 n6324 DFFQX1TS
Xfifo_from_fir_fifo_cell13_register_sr_reg[8]
+ fifo_from_fir_fifo_cell13_sr_out[8] clk__L1_N0 n6325 DFFQX1TS
Xfifo_from_fir_fifo_cell13_register_sr_reg[7]
+ fifo_from_fir_fifo_cell13_sr_out[7] clk__L1_N0 n6326 DFFQX1TS
Xfifo_from_fir_fifo_cell13_register_sr_reg[6]
+ fifo_from_fir_fifo_cell13_sr_out[6] clk__L1_N0 n6327 DFFQX1TS
Xfifo_from_fir_fifo_cell13_register_sr_reg[5]
+ fifo_from_fir_fifo_cell13_sr_out[5] clk__L1_N0 n6328 DFFQX1TS
Xfifo_from_fir_fifo_cell13_register_sr_reg[4]
+ fifo_from_fir_fifo_cell13_sr_out[4] clk__L1_N0 n6329 DFFQX1TS
Xfifo_from_fir_fifo_cell13_register_sr_reg[3]
+ fifo_from_fir_fifo_cell13_sr_out[3] clk__L1_N0 n6330 DFFQX1TS
Xfifo_from_fir_fifo_cell13_register_sr_reg[2]
+ fifo_from_fir_fifo_cell13_sr_out[2] clk__L1_N0 n6331 DFFQX1TS
Xfifo_from_fir_fifo_cell13_register_sr_reg[1]
+ fifo_from_fir_fifo_cell13_sr_out[1] clk__L1_N0 n6332 DFFQX1TS
Xfifo_from_fir_fifo_cell13_register_sr_reg[0]
+ fifo_from_fir_fifo_cell13_sr_out[0] clk__L1_N0 n6333 DFFQX1TS
Xfifo_from_fir_fifo_cell14_register_sr_reg[31]
+ fifo_from_fir_fifo_cell14_sr_out[31] clk__L1_N0 n6268 DFFQX1TS
Xfifo_from_fir_fifo_cell14_register_sr_reg[30]
+ fifo_from_fir_fifo_cell14_sr_out[30] clk__L1_N0 n6269 DFFQX1TS
Xfifo_from_fir_fifo_cell14_register_sr_reg[29]
+ fifo_from_fir_fifo_cell14_sr_out[29] clk__L1_N0 n6270 DFFQX1TS
Xfifo_from_fir_fifo_cell14_register_sr_reg[28]
+ fifo_from_fir_fifo_cell14_sr_out[28] clk__L1_N0 n6271 DFFQX1TS
Xfifo_from_fir_fifo_cell14_register_sr_reg[27]
+ fifo_from_fir_fifo_cell14_sr_out[27] clk__L1_N0 n6272 DFFQX1TS
Xfifo_from_fir_fifo_cell14_register_sr_reg[26]
+ fifo_from_fir_fifo_cell14_sr_out[26] clk__L1_N0 n6273 DFFQX1TS
Xfifo_from_fir_fifo_cell14_register_sr_reg[25]
+ fifo_from_fir_fifo_cell14_sr_out[25] clk__L1_N0 n6274 DFFQX1TS
Xfifo_from_fir_fifo_cell14_register_sr_reg[24]
+ fifo_from_fir_fifo_cell14_sr_out[24] clk__L1_N0 n6275 DFFQX1TS
Xfifo_from_fir_fifo_cell14_register_sr_reg[23]
+ fifo_from_fir_fifo_cell14_sr_out[23] clk__L1_N0 n6276 DFFQX1TS
Xfifo_from_fir_fifo_cell14_register_sr_reg[22]
+ fifo_from_fir_fifo_cell14_sr_out[22] clk__L1_N0 n6277 DFFQX1TS
Xfifo_from_fir_fifo_cell14_register_sr_reg[21]
+ fifo_from_fir_fifo_cell14_sr_out[21] clk__L1_N0 n6278 DFFQX1TS
Xfifo_from_fir_fifo_cell14_register_sr_reg[20]
+ fifo_from_fir_fifo_cell14_sr_out[20] clk__L1_N0 n6279 DFFQX1TS
Xfifo_from_fir_fifo_cell14_register_sr_reg[19]
+ fifo_from_fir_fifo_cell14_sr_out[19] clk__L1_N0 n6280 DFFQX1TS
Xfifo_from_fir_fifo_cell14_register_sr_reg[18]
+ fifo_from_fir_fifo_cell14_sr_out[18] clk__L1_N0 n6281 DFFQX1TS
Xfifo_from_fir_fifo_cell14_register_sr_reg[17]
+ fifo_from_fir_fifo_cell14_sr_out[17] clk__L1_N0 n6282 DFFQX1TS
Xfifo_from_fir_fifo_cell14_register_sr_reg[16]
+ fifo_from_fir_fifo_cell14_sr_out[16] clk__L1_N0 n6283 DFFQX1TS
Xfifo_from_fir_fifo_cell14_register_sr_reg[15]
+ fifo_from_fir_fifo_cell14_sr_out[15] clk__L1_N0 n6284 DFFQX1TS
Xfifo_from_fir_fifo_cell14_register_sr_reg[14]
+ fifo_from_fir_fifo_cell14_sr_out[14] clk__L1_N0 n6285 DFFQX1TS
Xfifo_from_fir_fifo_cell14_register_sr_reg[13]
+ fifo_from_fir_fifo_cell14_sr_out[13] clk__L1_N0 n6286 DFFQX1TS
Xfifo_from_fir_fifo_cell14_register_sr_reg[12]
+ fifo_from_fir_fifo_cell14_sr_out[12] clk__L1_N0 n6287 DFFQX1TS
Xfifo_from_fir_fifo_cell14_register_sr_reg[11]
+ fifo_from_fir_fifo_cell14_sr_out[11] clk__L1_N0 n6288 DFFQX1TS
Xfifo_from_fir_fifo_cell14_register_sr_reg[10]
+ fifo_from_fir_fifo_cell14_sr_out[10] clk__L1_N0 n6289 DFFQX1TS
Xfifo_from_fir_fifo_cell14_register_sr_reg[9]
+ fifo_from_fir_fifo_cell14_sr_out[9] clk__L1_N0 n6290 DFFQX1TS
Xfifo_from_fir_fifo_cell14_register_sr_reg[8]
+ fifo_from_fir_fifo_cell14_sr_out[8] clk__L1_N0 n6291 DFFQX1TS
Xfifo_from_fir_fifo_cell14_register_sr_reg[7]
+ fifo_from_fir_fifo_cell14_sr_out[7] clk__L1_N0 n6292 DFFQX1TS
Xfifo_from_fir_fifo_cell14_register_sr_reg[6]
+ fifo_from_fir_fifo_cell14_sr_out[6] clk__L1_N0 n6293 DFFQX1TS
Xfifo_from_fir_fifo_cell14_register_sr_reg[5]
+ fifo_from_fir_fifo_cell14_sr_out[5] clk__L1_N0 n6294 DFFQX1TS
Xfifo_from_fir_fifo_cell14_register_sr_reg[4]
+ fifo_from_fir_fifo_cell14_sr_out[4] clk__L1_N0 n6295 DFFQX1TS
Xfifo_from_fir_fifo_cell14_register_sr_reg[3]
+ fifo_from_fir_fifo_cell14_sr_out[3] clk__L1_N0 n6296 DFFQX1TS
Xfifo_from_fir_fifo_cell14_register_sr_reg[2]
+ fifo_from_fir_fifo_cell14_sr_out[2] clk__L1_N0 n6297 DFFQX1TS
Xfifo_from_fir_fifo_cell14_register_sr_reg[1]
+ fifo_from_fir_fifo_cell14_sr_out[1] clk__L1_N0 n6298 DFFQX1TS
Xfifo_from_fir_fifo_cell14_register_sr_reg[0]
+ fifo_from_fir_fifo_cell14_sr_out[0] clk__L1_N0 n6299 DFFQX1TS
Xfifo_from_fir_fifo_cell15_register_sr_reg[31]
+ fifo_from_fir_fifo_cell15_sr_out[31] clk__L1_N0 n6234 DFFQX1TS
Xfifo_from_fir_fifo_cell15_register_sr_reg[30]
+ fifo_from_fir_fifo_cell15_sr_out[30] clk__L1_N0 n6235 DFFQX1TS
Xfifo_from_fir_fifo_cell15_register_sr_reg[29]
+ fifo_from_fir_fifo_cell15_sr_out[29] clk__L1_N0 n6236 DFFQX1TS
Xfifo_from_fir_fifo_cell15_register_sr_reg[28]
+ fifo_from_fir_fifo_cell15_sr_out[28] clk__L1_N0 n6237 DFFQX1TS
Xfifo_from_fir_fifo_cell15_register_sr_reg[27]
+ fifo_from_fir_fifo_cell15_sr_out[27] clk__L1_N0 n6238 DFFQX1TS
Xfifo_from_fir_fifo_cell15_register_sr_reg[26]
+ fifo_from_fir_fifo_cell15_sr_out[26] clk__L1_N0 n6239 DFFQX1TS
Xfifo_from_fir_fifo_cell15_register_sr_reg[25]
+ fifo_from_fir_fifo_cell15_sr_out[25] clk__L1_N0 n6240 DFFQX1TS
Xfifo_from_fir_fifo_cell15_register_sr_reg[24]
+ fifo_from_fir_fifo_cell15_sr_out[24] clk__L1_N0 n6241 DFFQX1TS
Xfifo_from_fir_fifo_cell15_register_sr_reg[23]
+ fifo_from_fir_fifo_cell15_sr_out[23] clk__L1_N0 n6242 DFFQX1TS
Xfifo_from_fir_fifo_cell15_register_sr_reg[22]
+ fifo_from_fir_fifo_cell15_sr_out[22] clk__L1_N0 n6243 DFFQX1TS
Xfifo_from_fir_fifo_cell15_register_sr_reg[21]
+ fifo_from_fir_fifo_cell15_sr_out[21] clk__L1_N0 n6244 DFFQX1TS
Xfifo_from_fir_fifo_cell15_register_sr_reg[20]
+ fifo_from_fir_fifo_cell15_sr_out[20] clk__L1_N0 n6245 DFFQX1TS
Xfifo_from_fir_fifo_cell15_register_sr_reg[19]
+ fifo_from_fir_fifo_cell15_sr_out[19] clk__L1_N0 n6246 DFFQX1TS
Xfifo_from_fir_fifo_cell15_register_sr_reg[18]
+ fifo_from_fir_fifo_cell15_sr_out[18] clk__L1_N0 n6247 DFFQX1TS
Xfifo_from_fir_fifo_cell15_register_sr_reg[17]
+ fifo_from_fir_fifo_cell15_sr_out[17] clk__L1_N0 n6248 DFFQX1TS
Xfifo_from_fir_fifo_cell15_register_sr_reg[16]
+ fifo_from_fir_fifo_cell15_sr_out[16] clk__L1_N0 n6249 DFFQX1TS
Xfifo_from_fir_fifo_cell15_register_sr_reg[15]
+ fifo_from_fir_fifo_cell15_sr_out[15] clk__L1_N0 n6250 DFFQX1TS
Xfifo_from_fir_fifo_cell15_register_sr_reg[14]
+ fifo_from_fir_fifo_cell15_sr_out[14] clk__L1_N0 n6251 DFFQX1TS
Xfifo_from_fir_fifo_cell15_register_sr_reg[13]
+ fifo_from_fir_fifo_cell15_sr_out[13] clk__L1_N0 n6252 DFFQX1TS
Xfifo_from_fir_fifo_cell15_register_sr_reg[12]
+ fifo_from_fir_fifo_cell15_sr_out[12] clk__L1_N0 n6253 DFFQX1TS
Xfifo_from_fir_fifo_cell15_register_sr_reg[11]
+ fifo_from_fir_fifo_cell15_sr_out[11] clk__L1_N0 n6254 DFFQX1TS
Xfifo_from_fir_fifo_cell15_register_sr_reg[10]
+ fifo_from_fir_fifo_cell15_sr_out[10] clk__L1_N0 n6255 DFFQX1TS
Xfifo_from_fir_fifo_cell15_register_sr_reg[9]
+ fifo_from_fir_fifo_cell15_sr_out[9] clk__L1_N0 n6256 DFFQX1TS
Xfifo_from_fir_fifo_cell15_register_sr_reg[8]
+ fifo_from_fir_fifo_cell15_sr_out[8] clk__L1_N0 n6257 DFFQX1TS
Xfifo_from_fir_fifo_cell15_register_sr_reg[7]
+ fifo_from_fir_fifo_cell15_sr_out[7] clk__L1_N0 n6258 DFFQX1TS
Xfifo_from_fir_fifo_cell15_register_sr_reg[6]
+ fifo_from_fir_fifo_cell15_sr_out[6] clk__L1_N0 n6259 DFFQX1TS
Xfifo_from_fir_fifo_cell15_register_sr_reg[5]
+ fifo_from_fir_fifo_cell15_sr_out[5] clk__L1_N0 n6260 DFFQX1TS
Xfifo_from_fir_fifo_cell15_register_sr_reg[4]
+ fifo_from_fir_fifo_cell15_sr_out[4] clk__L1_N0 n6261 DFFQX1TS
Xfifo_from_fir_fifo_cell15_register_sr_reg[3]
+ fifo_from_fir_fifo_cell15_sr_out[3] clk__L1_N0 n6262 DFFQX1TS
Xfifo_from_fir_fifo_cell15_register_sr_reg[2]
+ fifo_from_fir_fifo_cell15_sr_out[2] clk__L1_N0 n6263 DFFQX1TS
Xfifo_from_fir_fifo_cell15_register_sr_reg[1]
+ fifo_from_fir_fifo_cell15_sr_out[1] clk__L1_N0 n6264 DFFQX1TS
Xfifo_from_fir_fifo_cell15_register_sr_reg[0]
+ fifo_from_fir_fifo_cell15_sr_out[0] clk__L1_N0 n6265 DFFQX1TS
Xfifo_from_fft_fifo_cell0_register_sr_reg[31]
+ fifo_from_fft_fifo_cell0_sr_out[31] clk__L1_N0 n5420 DFFQX1TS
Xfifo_from_fft_fifo_cell0_register_sr_reg[30]
+ fifo_from_fft_fifo_cell0_sr_out[30] clk__L1_N0 n5421 DFFQX1TS
Xfifo_from_fft_fifo_cell0_register_sr_reg[29]
+ fifo_from_fft_fifo_cell0_sr_out[29] clk__L1_N0 n5422 DFFQX1TS
Xfifo_from_fft_fifo_cell0_register_sr_reg[28]
+ fifo_from_fft_fifo_cell0_sr_out[28] clk__L1_N0 n5423 DFFQX1TS
Xfifo_from_fft_fifo_cell0_register_sr_reg[27]
+ fifo_from_fft_fifo_cell0_sr_out[27] clk__L1_N0 n5424 DFFQX1TS
Xfifo_from_fft_fifo_cell0_register_sr_reg[26]
+ fifo_from_fft_fifo_cell0_sr_out[26] clk__L1_N0 n5425 DFFQX1TS
Xfifo_from_fft_fifo_cell0_register_sr_reg[25]
+ fifo_from_fft_fifo_cell0_sr_out[25] clk__L1_N0 n5426 DFFQX1TS
Xfifo_from_fft_fifo_cell0_register_sr_reg[24]
+ fifo_from_fft_fifo_cell0_sr_out[24] clk__L1_N0 n5427 DFFQX1TS
Xfifo_from_fft_fifo_cell0_register_sr_reg[23]
+ fifo_from_fft_fifo_cell0_sr_out[23] clk__L1_N0 n5428 DFFQX1TS
Xfifo_from_fft_fifo_cell0_register_sr_reg[22]
+ fifo_from_fft_fifo_cell0_sr_out[22] clk__L1_N0 n5429 DFFQX1TS
Xfifo_from_fft_fifo_cell0_register_sr_reg[21]
+ fifo_from_fft_fifo_cell0_sr_out[21] clk__L1_N0 n5430 DFFQX1TS
Xfifo_from_fft_fifo_cell0_register_sr_reg[20]
+ fifo_from_fft_fifo_cell0_sr_out[20] clk__L1_N0 n5431 DFFQX1TS
Xfifo_from_fft_fifo_cell0_register_sr_reg[19]
+ fifo_from_fft_fifo_cell0_sr_out[19] clk__L1_N0 n5432 DFFQX1TS
Xfifo_from_fft_fifo_cell0_register_sr_reg[18]
+ fifo_from_fft_fifo_cell0_sr_out[18] clk__L1_N0 n5433 DFFQX1TS
Xfifo_from_fft_fifo_cell0_register_sr_reg[17]
+ fifo_from_fft_fifo_cell0_sr_out[17] clk__L1_N0 n5434 DFFQX1TS
Xfifo_from_fft_fifo_cell0_register_sr_reg[16]
+ fifo_from_fft_fifo_cell0_sr_out[16] clk__L1_N0 n5435 DFFQX1TS
Xfifo_from_fft_fifo_cell0_register_sr_reg[15]
+ fifo_from_fft_fifo_cell0_sr_out[15] clk__L1_N0 n5436 DFFQX1TS
Xfifo_from_fft_fifo_cell0_register_sr_reg[14]
+ fifo_from_fft_fifo_cell0_sr_out[14] clk__L1_N0 n5437 DFFQX1TS
Xfifo_from_fft_fifo_cell0_register_sr_reg[13]
+ fifo_from_fft_fifo_cell0_sr_out[13] clk__L1_N0 n5438 DFFQX1TS
Xfifo_from_fft_fifo_cell0_register_sr_reg[12]
+ fifo_from_fft_fifo_cell0_sr_out[12] clk__L1_N0 n5439 DFFQX1TS
Xfifo_from_fft_fifo_cell0_register_sr_reg[11]
+ fifo_from_fft_fifo_cell0_sr_out[11] clk__L1_N0 n5440 DFFQX1TS
Xfifo_from_fft_fifo_cell0_register_sr_reg[10]
+ fifo_from_fft_fifo_cell0_sr_out[10] clk__L1_N0 n5441 DFFQX1TS
Xfifo_from_fft_fifo_cell0_register_sr_reg[9] fifo_from_fft_fifo_cell0_sr_out[9]
+ clk__L1_N0 n5442 DFFQX1TS
Xfifo_from_fft_fifo_cell0_register_sr_reg[8] fifo_from_fft_fifo_cell0_sr_out[8]
+ clk__L1_N0 n5443 DFFQX1TS
Xfifo_from_fft_fifo_cell0_register_sr_reg[7] fifo_from_fft_fifo_cell0_sr_out[7]
+ clk__L1_N0 n5444 DFFQX1TS
Xfifo_from_fft_fifo_cell0_register_sr_reg[6] fifo_from_fft_fifo_cell0_sr_out[6]
+ clk__L1_N0 n5445 DFFQX1TS
Xfifo_from_fft_fifo_cell0_register_sr_reg[5] fifo_from_fft_fifo_cell0_sr_out[5]
+ clk__L1_N0 n5446 DFFQX1TS
Xfifo_from_fft_fifo_cell0_register_sr_reg[4] fifo_from_fft_fifo_cell0_sr_out[4]
+ clk__L1_N0 n5447 DFFQX1TS
Xfifo_from_fft_fifo_cell0_register_sr_reg[3] fifo_from_fft_fifo_cell0_sr_out[3]
+ clk__L1_N0 n5448 DFFQX1TS
Xfifo_from_fft_fifo_cell0_register_sr_reg[2] fifo_from_fft_fifo_cell0_sr_out[2]
+ clk__L1_N0 n5449 DFFQX1TS
Xfifo_from_fft_fifo_cell0_register_sr_reg[1] fifo_from_fft_fifo_cell0_sr_out[1]
+ clk__L1_N0 n5450 DFFQX1TS
Xfifo_from_fft_fifo_cell0_register_sr_reg[0] fifo_from_fft_fifo_cell0_sr_out[0]
+ clk__L1_N0 n5451 DFFQX1TS
Xfifo_from_fft_fifo_cell1_register_sr_reg[31]
+ fifo_from_fft_fifo_cell1_sr_out[31] clk__L1_N0 n6181 DFFQX1TS
Xfifo_from_fft_fifo_cell1_register_sr_reg[30]
+ fifo_from_fft_fifo_cell1_sr_out[30] clk__L1_N0 n6182 DFFQX1TS
Xfifo_from_fft_fifo_cell1_register_sr_reg[29]
+ fifo_from_fft_fifo_cell1_sr_out[29] clk__L1_N0 n6183 DFFQX1TS
Xfifo_from_fft_fifo_cell1_register_sr_reg[28]
+ fifo_from_fft_fifo_cell1_sr_out[28] clk__L1_N0 n6184 DFFQX1TS
Xfifo_from_fft_fifo_cell1_register_sr_reg[27]
+ fifo_from_fft_fifo_cell1_sr_out[27] clk__L1_N0 n6185 DFFQX1TS
Xfifo_from_fft_fifo_cell1_register_sr_reg[26]
+ fifo_from_fft_fifo_cell1_sr_out[26] clk__L1_N0 n6186 DFFQX1TS
Xfifo_from_fft_fifo_cell1_register_sr_reg[25]
+ fifo_from_fft_fifo_cell1_sr_out[25] clk__L1_N0 n6187 DFFQX1TS
Xfifo_from_fft_fifo_cell1_register_sr_reg[24]
+ fifo_from_fft_fifo_cell1_sr_out[24] clk__L1_N0 n6188 DFFQX1TS
Xfifo_from_fft_fifo_cell1_register_sr_reg[23]
+ fifo_from_fft_fifo_cell1_sr_out[23] clk__L1_N0 n6189 DFFQX1TS
Xfifo_from_fft_fifo_cell1_register_sr_reg[22]
+ fifo_from_fft_fifo_cell1_sr_out[22] clk__L1_N0 n6190 DFFQX1TS
Xfifo_from_fft_fifo_cell1_register_sr_reg[21]
+ fifo_from_fft_fifo_cell1_sr_out[21] clk__L1_N0 n6191 DFFQX1TS
Xfifo_from_fft_fifo_cell1_register_sr_reg[20]
+ fifo_from_fft_fifo_cell1_sr_out[20] clk__L1_N0 n6192 DFFQX1TS
Xfifo_from_fft_fifo_cell1_register_sr_reg[19]
+ fifo_from_fft_fifo_cell1_sr_out[19] clk__L1_N0 n6193 DFFQX1TS
Xfifo_from_fft_fifo_cell1_register_sr_reg[18]
+ fifo_from_fft_fifo_cell1_sr_out[18] clk__L1_N0 n6194 DFFQX1TS
Xfifo_from_fft_fifo_cell1_register_sr_reg[17]
+ fifo_from_fft_fifo_cell1_sr_out[17] clk__L1_N0 n6195 DFFQX1TS
Xfifo_from_fft_fifo_cell1_register_sr_reg[16]
+ fifo_from_fft_fifo_cell1_sr_out[16] clk__L1_N0 n6196 DFFQX1TS
Xfifo_from_fft_fifo_cell1_register_sr_reg[15]
+ fifo_from_fft_fifo_cell1_sr_out[15] clk__L1_N0 n6197 DFFQX1TS
Xfifo_from_fft_fifo_cell1_register_sr_reg[14]
+ fifo_from_fft_fifo_cell1_sr_out[14] clk__L1_N0 n6198 DFFQX1TS
Xfifo_from_fft_fifo_cell1_register_sr_reg[13]
+ fifo_from_fft_fifo_cell1_sr_out[13] clk__L1_N0 n6199 DFFQX1TS
Xfifo_from_fft_fifo_cell1_register_sr_reg[12]
+ fifo_from_fft_fifo_cell1_sr_out[12] clk__L1_N0 n6200 DFFQX1TS
Xfifo_from_fft_fifo_cell1_register_sr_reg[11]
+ fifo_from_fft_fifo_cell1_sr_out[11] clk__L1_N0 n6201 DFFQX1TS
Xfifo_from_fft_fifo_cell1_register_sr_reg[10]
+ fifo_from_fft_fifo_cell1_sr_out[10] clk__L1_N0 n6202 DFFQX1TS
Xfifo_from_fft_fifo_cell1_register_sr_reg[9] fifo_from_fft_fifo_cell1_sr_out[9]
+ clk__L1_N0 n6203 DFFQX1TS
Xfifo_from_fft_fifo_cell1_register_sr_reg[8] fifo_from_fft_fifo_cell1_sr_out[8]
+ clk__L1_N0 n6204 DFFQX1TS
Xfifo_from_fft_fifo_cell1_register_sr_reg[7] fifo_from_fft_fifo_cell1_sr_out[7]
+ clk__L1_N0 n6205 DFFQX1TS
Xfifo_from_fft_fifo_cell1_register_sr_reg[6] fifo_from_fft_fifo_cell1_sr_out[6]
+ clk__L1_N0 n6206 DFFQX1TS
Xfifo_from_fft_fifo_cell1_register_sr_reg[5] fifo_from_fft_fifo_cell1_sr_out[5]
+ clk__L1_N0 n6207 DFFQX1TS
Xfifo_from_fft_fifo_cell1_register_sr_reg[4] fifo_from_fft_fifo_cell1_sr_out[4]
+ clk__L1_N0 n6208 DFFQX1TS
Xfifo_from_fft_fifo_cell1_register_sr_reg[3] fifo_from_fft_fifo_cell1_sr_out[3]
+ clk__L1_N0 n6209 DFFQX1TS
Xfifo_from_fft_fifo_cell1_register_sr_reg[2] fifo_from_fft_fifo_cell1_sr_out[2]
+ clk__L1_N0 n6210 DFFQX1TS
Xfifo_from_fft_fifo_cell1_register_sr_reg[1] fifo_from_fft_fifo_cell1_sr_out[1]
+ clk__L1_N0 n6211 DFFQX1TS
Xfifo_from_fft_fifo_cell1_register_sr_reg[0] fifo_from_fft_fifo_cell1_sr_out[0]
+ clk__L1_N0 n6212 DFFQX1TS
Xfifo_from_fft_fifo_cell2_register_sr_reg[31]
+ fifo_from_fft_fifo_cell2_sr_out[31] clk__L1_N0 n6147 DFFQX1TS
Xfifo_from_fft_fifo_cell2_register_sr_reg[30]
+ fifo_from_fft_fifo_cell2_sr_out[30] clk__L1_N0 n6148 DFFQX1TS
Xfifo_from_fft_fifo_cell2_register_sr_reg[29]
+ fifo_from_fft_fifo_cell2_sr_out[29] clk__L1_N0 n6149 DFFQX1TS
Xfifo_from_fft_fifo_cell2_register_sr_reg[28]
+ fifo_from_fft_fifo_cell2_sr_out[28] clk__L1_N0 n6150 DFFQX1TS
Xfifo_from_fft_fifo_cell2_register_sr_reg[27]
+ fifo_from_fft_fifo_cell2_sr_out[27] clk__L1_N0 n6151 DFFQX1TS
Xfifo_from_fft_fifo_cell2_register_sr_reg[26]
+ fifo_from_fft_fifo_cell2_sr_out[26] clk__L1_N0 n6152 DFFQX1TS
Xfifo_from_fft_fifo_cell2_register_sr_reg[25]
+ fifo_from_fft_fifo_cell2_sr_out[25] clk__L1_N0 n6153 DFFQX1TS
Xfifo_from_fft_fifo_cell2_register_sr_reg[24]
+ fifo_from_fft_fifo_cell2_sr_out[24] clk__L1_N0 n6154 DFFQX1TS
Xfifo_from_fft_fifo_cell2_register_sr_reg[23]
+ fifo_from_fft_fifo_cell2_sr_out[23] clk__L1_N0 n6155 DFFQX1TS
Xfifo_from_fft_fifo_cell2_register_sr_reg[22]
+ fifo_from_fft_fifo_cell2_sr_out[22] clk__L1_N0 n6156 DFFQX1TS
Xfifo_from_fft_fifo_cell2_register_sr_reg[21]
+ fifo_from_fft_fifo_cell2_sr_out[21] clk__L1_N0 n6157 DFFQX1TS
Xfifo_from_fft_fifo_cell2_register_sr_reg[20]
+ fifo_from_fft_fifo_cell2_sr_out[20] clk__L1_N0 n6158 DFFQX1TS
Xfifo_from_fft_fifo_cell2_register_sr_reg[19]
+ fifo_from_fft_fifo_cell2_sr_out[19] clk__L1_N0 n6159 DFFQX1TS
Xfifo_from_fft_fifo_cell2_register_sr_reg[18]
+ fifo_from_fft_fifo_cell2_sr_out[18] clk__L1_N0 n6160 DFFQX1TS
Xfifo_from_fft_fifo_cell2_register_sr_reg[17]
+ fifo_from_fft_fifo_cell2_sr_out[17] clk__L1_N0 n6161 DFFQX1TS
Xfifo_from_fft_fifo_cell2_register_sr_reg[16]
+ fifo_from_fft_fifo_cell2_sr_out[16] clk__L1_N0 n6162 DFFQX1TS
Xfifo_from_fft_fifo_cell2_register_sr_reg[15]
+ fifo_from_fft_fifo_cell2_sr_out[15] clk__L1_N0 n6163 DFFQX1TS
Xfifo_from_fft_fifo_cell2_register_sr_reg[14]
+ fifo_from_fft_fifo_cell2_sr_out[14] clk__L1_N0 n6164 DFFQX1TS
Xfifo_from_fft_fifo_cell2_register_sr_reg[13]
+ fifo_from_fft_fifo_cell2_sr_out[13] clk__L1_N0 n6165 DFFQX1TS
Xfifo_from_fft_fifo_cell2_register_sr_reg[12]
+ fifo_from_fft_fifo_cell2_sr_out[12] clk__L1_N0 n6166 DFFQX1TS
Xfifo_from_fft_fifo_cell2_register_sr_reg[11]
+ fifo_from_fft_fifo_cell2_sr_out[11] clk__L1_N0 n6167 DFFQX1TS
Xfifo_from_fft_fifo_cell2_register_sr_reg[10]
+ fifo_from_fft_fifo_cell2_sr_out[10] clk__L1_N0 n6168 DFFQX1TS
Xfifo_from_fft_fifo_cell2_register_sr_reg[9] fifo_from_fft_fifo_cell2_sr_out[9]
+ clk__L1_N0 n6169 DFFQX1TS
Xfifo_from_fft_fifo_cell2_register_sr_reg[8] fifo_from_fft_fifo_cell2_sr_out[8]
+ clk__L1_N0 n6170 DFFQX1TS
Xfifo_from_fft_fifo_cell2_register_sr_reg[7] fifo_from_fft_fifo_cell2_sr_out[7]
+ clk__L1_N0 n6171 DFFQX1TS
Xfifo_from_fft_fifo_cell2_register_sr_reg[6] fifo_from_fft_fifo_cell2_sr_out[6]
+ clk__L1_N0 n6172 DFFQX1TS
Xfifo_from_fft_fifo_cell2_register_sr_reg[5] fifo_from_fft_fifo_cell2_sr_out[5]
+ clk__L1_N0 n6173 DFFQX1TS
Xfifo_from_fft_fifo_cell2_register_sr_reg[4] fifo_from_fft_fifo_cell2_sr_out[4]
+ clk__L1_N0 n6174 DFFQX1TS
Xfifo_from_fft_fifo_cell2_register_sr_reg[3] fifo_from_fft_fifo_cell2_sr_out[3]
+ clk__L1_N0 n6175 DFFQX1TS
Xfifo_from_fft_fifo_cell2_register_sr_reg[2] fifo_from_fft_fifo_cell2_sr_out[2]
+ clk__L1_N0 n6176 DFFQX1TS
Xfifo_from_fft_fifo_cell2_register_sr_reg[1] fifo_from_fft_fifo_cell2_sr_out[1]
+ clk__L1_N0 n6177 DFFQX1TS
Xfifo_from_fft_fifo_cell2_register_sr_reg[0] fifo_from_fft_fifo_cell2_sr_out[0]
+ clk__L1_N0 n6178 DFFQX1TS
Xfifo_from_fft_fifo_cell3_register_sr_reg[31]
+ fifo_from_fft_fifo_cell3_sr_out[31] clk__L1_N0 n6113 DFFQX1TS
Xfifo_from_fft_fifo_cell3_register_sr_reg[30]
+ fifo_from_fft_fifo_cell3_sr_out[30] clk__L1_N0 n6114 DFFQX1TS
Xfifo_from_fft_fifo_cell3_register_sr_reg[29]
+ fifo_from_fft_fifo_cell3_sr_out[29] clk__L1_N0 n6115 DFFQX1TS
Xfifo_from_fft_fifo_cell3_register_sr_reg[28]
+ fifo_from_fft_fifo_cell3_sr_out[28] clk__L1_N0 n6116 DFFQX1TS
Xfifo_from_fft_fifo_cell3_register_sr_reg[27]
+ fifo_from_fft_fifo_cell3_sr_out[27] clk__L1_N0 n6117 DFFQX1TS
Xfifo_from_fft_fifo_cell3_register_sr_reg[26]
+ fifo_from_fft_fifo_cell3_sr_out[26] clk__L1_N0 n6118 DFFQX1TS
Xfifo_from_fft_fifo_cell3_register_sr_reg[25]
+ fifo_from_fft_fifo_cell3_sr_out[25] clk__L1_N0 n6119 DFFQX1TS
Xfifo_from_fft_fifo_cell3_register_sr_reg[24]
+ fifo_from_fft_fifo_cell3_sr_out[24] clk__L1_N0 n6120 DFFQX1TS
Xfifo_from_fft_fifo_cell3_register_sr_reg[23]
+ fifo_from_fft_fifo_cell3_sr_out[23] clk__L1_N0 n6121 DFFQX1TS
Xfifo_from_fft_fifo_cell3_register_sr_reg[22]
+ fifo_from_fft_fifo_cell3_sr_out[22] clk__L1_N0 n6122 DFFQX1TS
Xfifo_from_fft_fifo_cell3_register_sr_reg[21]
+ fifo_from_fft_fifo_cell3_sr_out[21] clk__L1_N0 n6123 DFFQX1TS
Xfifo_from_fft_fifo_cell3_register_sr_reg[20]
+ fifo_from_fft_fifo_cell3_sr_out[20] clk__L1_N0 n6124 DFFQX1TS
Xfifo_from_fft_fifo_cell3_register_sr_reg[19]
+ fifo_from_fft_fifo_cell3_sr_out[19] clk__L1_N0 n6125 DFFQX1TS
Xfifo_from_fft_fifo_cell3_register_sr_reg[18]
+ fifo_from_fft_fifo_cell3_sr_out[18] clk__L1_N0 n6126 DFFQX1TS
Xfifo_from_fft_fifo_cell3_register_sr_reg[17]
+ fifo_from_fft_fifo_cell3_sr_out[17] clk__L1_N0 n6127 DFFQX1TS
Xfifo_from_fft_fifo_cell3_register_sr_reg[16]
+ fifo_from_fft_fifo_cell3_sr_out[16] clk__L1_N0 n6128 DFFQX1TS
Xfifo_from_fft_fifo_cell3_register_sr_reg[15]
+ fifo_from_fft_fifo_cell3_sr_out[15] clk__L1_N0 n6129 DFFQX1TS
Xfifo_from_fft_fifo_cell3_register_sr_reg[14]
+ fifo_from_fft_fifo_cell3_sr_out[14] clk__L1_N0 n6130 DFFQX1TS
Xfifo_from_fft_fifo_cell3_register_sr_reg[13]
+ fifo_from_fft_fifo_cell3_sr_out[13] clk__L1_N0 n6131 DFFQX1TS
Xfifo_from_fft_fifo_cell3_register_sr_reg[12]
+ fifo_from_fft_fifo_cell3_sr_out[12] clk__L1_N0 n6132 DFFQX1TS
Xfifo_from_fft_fifo_cell3_register_sr_reg[11]
+ fifo_from_fft_fifo_cell3_sr_out[11] clk__L1_N0 n6133 DFFQX1TS
Xfifo_from_fft_fifo_cell3_register_sr_reg[10]
+ fifo_from_fft_fifo_cell3_sr_out[10] clk__L1_N0 n6134 DFFQX1TS
Xfifo_from_fft_fifo_cell3_register_sr_reg[9] fifo_from_fft_fifo_cell3_sr_out[9]
+ clk__L1_N0 n6135 DFFQX1TS
Xfifo_from_fft_fifo_cell3_register_sr_reg[8] fifo_from_fft_fifo_cell3_sr_out[8]
+ clk__L1_N0 n6136 DFFQX1TS
Xfifo_from_fft_fifo_cell3_register_sr_reg[7] fifo_from_fft_fifo_cell3_sr_out[7]
+ clk__L1_N0 n6137 DFFQX1TS
Xfifo_from_fft_fifo_cell3_register_sr_reg[6] fifo_from_fft_fifo_cell3_sr_out[6]
+ clk__L1_N0 n6138 DFFQX1TS
Xfifo_from_fft_fifo_cell3_register_sr_reg[5] fifo_from_fft_fifo_cell3_sr_out[5]
+ clk__L1_N0 n6139 DFFQX1TS
Xfifo_from_fft_fifo_cell3_register_sr_reg[4] fifo_from_fft_fifo_cell3_sr_out[4]
+ clk__L1_N0 n6140 DFFQX1TS
Xfifo_from_fft_fifo_cell3_register_sr_reg[3] fifo_from_fft_fifo_cell3_sr_out[3]
+ clk__L1_N0 n6141 DFFQX1TS
Xfifo_from_fft_fifo_cell3_register_sr_reg[2] fifo_from_fft_fifo_cell3_sr_out[2]
+ clk__L1_N0 n6142 DFFQX1TS
Xfifo_from_fft_fifo_cell3_register_sr_reg[1] fifo_from_fft_fifo_cell3_sr_out[1]
+ clk__L1_N0 n6143 DFFQX1TS
Xfifo_from_fft_fifo_cell3_register_sr_reg[0] fifo_from_fft_fifo_cell3_sr_out[0]
+ clk__L1_N0 n6144 DFFQX1TS
Xfifo_from_fft_fifo_cell4_register_sr_reg[31]
+ fifo_from_fft_fifo_cell4_sr_out[31] clk__L1_N0 n6079 DFFQX1TS
Xfifo_from_fft_fifo_cell4_register_sr_reg[30]
+ fifo_from_fft_fifo_cell4_sr_out[30] clk__L1_N0 n6080 DFFQX1TS
Xfifo_from_fft_fifo_cell4_register_sr_reg[29]
+ fifo_from_fft_fifo_cell4_sr_out[29] clk__L1_N0 n6081 DFFQX1TS
Xfifo_from_fft_fifo_cell4_register_sr_reg[28]
+ fifo_from_fft_fifo_cell4_sr_out[28] clk__L1_N0 n6082 DFFQX1TS
Xfifo_from_fft_fifo_cell4_register_sr_reg[27]
+ fifo_from_fft_fifo_cell4_sr_out[27] clk__L1_N0 n6083 DFFQX1TS
Xfifo_from_fft_fifo_cell4_register_sr_reg[26]
+ fifo_from_fft_fifo_cell4_sr_out[26] clk__L1_N0 n6084 DFFQX1TS
Xfifo_from_fft_fifo_cell4_register_sr_reg[25]
+ fifo_from_fft_fifo_cell4_sr_out[25] clk__L1_N0 n6085 DFFQX1TS
Xfifo_from_fft_fifo_cell4_register_sr_reg[24]
+ fifo_from_fft_fifo_cell4_sr_out[24] clk__L1_N0 n6086 DFFQX1TS
Xfifo_from_fft_fifo_cell4_register_sr_reg[23]
+ fifo_from_fft_fifo_cell4_sr_out[23] clk__L1_N0 n6087 DFFQX1TS
Xfifo_from_fft_fifo_cell4_register_sr_reg[22]
+ fifo_from_fft_fifo_cell4_sr_out[22] clk__L1_N0 n6088 DFFQX1TS
Xfifo_from_fft_fifo_cell4_register_sr_reg[21]
+ fifo_from_fft_fifo_cell4_sr_out[21] clk__L1_N0 n6089 DFFQX1TS
Xfifo_from_fft_fifo_cell4_register_sr_reg[20]
+ fifo_from_fft_fifo_cell4_sr_out[20] clk__L1_N0 n6090 DFFQX1TS
Xfifo_from_fft_fifo_cell4_register_sr_reg[19]
+ fifo_from_fft_fifo_cell4_sr_out[19] clk__L1_N0 n6091 DFFQX1TS
Xfifo_from_fft_fifo_cell4_register_sr_reg[18]
+ fifo_from_fft_fifo_cell4_sr_out[18] clk__L1_N0 n6092 DFFQX1TS
Xfifo_from_fft_fifo_cell4_register_sr_reg[17]
+ fifo_from_fft_fifo_cell4_sr_out[17] clk__L1_N0 n6093 DFFQX1TS
Xfifo_from_fft_fifo_cell4_register_sr_reg[16]
+ fifo_from_fft_fifo_cell4_sr_out[16] clk__L1_N0 n6094 DFFQX1TS
Xfifo_from_fft_fifo_cell4_register_sr_reg[15]
+ fifo_from_fft_fifo_cell4_sr_out[15] clk__L1_N0 n6095 DFFQX1TS
Xfifo_from_fft_fifo_cell4_register_sr_reg[14]
+ fifo_from_fft_fifo_cell4_sr_out[14] clk__L1_N0 n6096 DFFQX1TS
Xfifo_from_fft_fifo_cell4_register_sr_reg[13]
+ fifo_from_fft_fifo_cell4_sr_out[13] clk__L1_N0 n6097 DFFQX1TS
Xfifo_from_fft_fifo_cell4_register_sr_reg[12]
+ fifo_from_fft_fifo_cell4_sr_out[12] clk__L1_N0 n6098 DFFQX1TS
Xfifo_from_fft_fifo_cell4_register_sr_reg[11]
+ fifo_from_fft_fifo_cell4_sr_out[11] clk__L1_N0 n6099 DFFQX1TS
Xfifo_from_fft_fifo_cell4_register_sr_reg[10]
+ fifo_from_fft_fifo_cell4_sr_out[10] clk__L1_N0 n6100 DFFQX1TS
Xfifo_from_fft_fifo_cell4_register_sr_reg[9] fifo_from_fft_fifo_cell4_sr_out[9]
+ clk__L1_N0 n6101 DFFQX1TS
Xfifo_from_fft_fifo_cell4_register_sr_reg[8] fifo_from_fft_fifo_cell4_sr_out[8]
+ clk__L1_N0 n6102 DFFQX1TS
Xfifo_from_fft_fifo_cell4_register_sr_reg[7] fifo_from_fft_fifo_cell4_sr_out[7]
+ clk__L1_N0 n6103 DFFQX1TS
Xfifo_from_fft_fifo_cell4_register_sr_reg[6] fifo_from_fft_fifo_cell4_sr_out[6]
+ clk__L1_N0 n6104 DFFQX1TS
Xfifo_from_fft_fifo_cell4_register_sr_reg[5] fifo_from_fft_fifo_cell4_sr_out[5]
+ clk__L1_N0 n6105 DFFQX1TS
Xfifo_from_fft_fifo_cell4_register_sr_reg[4] fifo_from_fft_fifo_cell4_sr_out[4]
+ clk__L1_N0 n6106 DFFQX1TS
Xfifo_from_fft_fifo_cell4_register_sr_reg[3] fifo_from_fft_fifo_cell4_sr_out[3]
+ clk__L1_N0 n6107 DFFQX1TS
Xfifo_from_fft_fifo_cell4_register_sr_reg[2] fifo_from_fft_fifo_cell4_sr_out[2]
+ clk__L1_N0 n6108 DFFQX1TS
Xfifo_from_fft_fifo_cell4_register_sr_reg[1] fifo_from_fft_fifo_cell4_sr_out[1]
+ clk__L1_N0 n6109 DFFQX1TS
Xfifo_from_fft_fifo_cell4_register_sr_reg[0] fifo_from_fft_fifo_cell4_sr_out[0]
+ clk__L1_N0 n6110 DFFQX1TS
Xfifo_from_fft_fifo_cell5_register_sr_reg[31]
+ fifo_from_fft_fifo_cell5_sr_out[31] clk__L1_N0 n6045 DFFQX1TS
Xfifo_from_fft_fifo_cell5_register_sr_reg[30]
+ fifo_from_fft_fifo_cell5_sr_out[30] clk__L1_N0 n6046 DFFQX1TS
Xfifo_from_fft_fifo_cell5_register_sr_reg[29]
+ fifo_from_fft_fifo_cell5_sr_out[29] clk__L1_N0 n6047 DFFQX1TS
Xfifo_from_fft_fifo_cell5_register_sr_reg[28]
+ fifo_from_fft_fifo_cell5_sr_out[28] clk__L1_N0 n6048 DFFQX1TS
Xfifo_from_fft_fifo_cell5_register_sr_reg[27]
+ fifo_from_fft_fifo_cell5_sr_out[27] clk__L1_N0 n6049 DFFQX1TS
Xfifo_from_fft_fifo_cell5_register_sr_reg[26]
+ fifo_from_fft_fifo_cell5_sr_out[26] clk__L1_N0 n6050 DFFQX1TS
Xfifo_from_fft_fifo_cell5_register_sr_reg[25]
+ fifo_from_fft_fifo_cell5_sr_out[25] clk__L1_N0 n6051 DFFQX1TS
Xfifo_from_fft_fifo_cell5_register_sr_reg[24]
+ fifo_from_fft_fifo_cell5_sr_out[24] clk__L1_N0 n6052 DFFQX1TS
Xfifo_from_fft_fifo_cell5_register_sr_reg[23]
+ fifo_from_fft_fifo_cell5_sr_out[23] clk__L1_N0 n6053 DFFQX1TS
Xfifo_from_fft_fifo_cell5_register_sr_reg[22]
+ fifo_from_fft_fifo_cell5_sr_out[22] clk__L1_N0 n6054 DFFQX1TS
Xfifo_from_fft_fifo_cell5_register_sr_reg[21]
+ fifo_from_fft_fifo_cell5_sr_out[21] clk__L1_N0 n6055 DFFQX1TS
Xfifo_from_fft_fifo_cell5_register_sr_reg[20]
+ fifo_from_fft_fifo_cell5_sr_out[20] clk__L1_N0 n6056 DFFQX1TS
Xfifo_from_fft_fifo_cell5_register_sr_reg[19]
+ fifo_from_fft_fifo_cell5_sr_out[19] clk__L1_N0 n6057 DFFQX1TS
Xfifo_from_fft_fifo_cell5_register_sr_reg[18]
+ fifo_from_fft_fifo_cell5_sr_out[18] clk__L1_N0 n6058 DFFQX1TS
Xfifo_from_fft_fifo_cell5_register_sr_reg[17]
+ fifo_from_fft_fifo_cell5_sr_out[17] clk__L1_N0 n6059 DFFQX1TS
Xfifo_from_fft_fifo_cell5_register_sr_reg[16]
+ fifo_from_fft_fifo_cell5_sr_out[16] clk__L1_N0 n6060 DFFQX1TS
Xfifo_from_fft_fifo_cell5_register_sr_reg[15]
+ fifo_from_fft_fifo_cell5_sr_out[15] clk__L1_N0 n6061 DFFQX1TS
Xfifo_from_fft_fifo_cell5_register_sr_reg[14]
+ fifo_from_fft_fifo_cell5_sr_out[14] clk__L1_N0 n6062 DFFQX1TS
Xfifo_from_fft_fifo_cell5_register_sr_reg[13]
+ fifo_from_fft_fifo_cell5_sr_out[13] clk__L1_N0 n6063 DFFQX1TS
Xfifo_from_fft_fifo_cell5_register_sr_reg[12]
+ fifo_from_fft_fifo_cell5_sr_out[12] clk__L1_N0 n6064 DFFQX1TS
Xfifo_from_fft_fifo_cell5_register_sr_reg[11]
+ fifo_from_fft_fifo_cell5_sr_out[11] clk__L1_N0 n6065 DFFQX1TS
Xfifo_from_fft_fifo_cell5_register_sr_reg[10]
+ fifo_from_fft_fifo_cell5_sr_out[10] clk__L1_N0 n6066 DFFQX1TS
Xfifo_from_fft_fifo_cell5_register_sr_reg[9] fifo_from_fft_fifo_cell5_sr_out[9]
+ clk__L1_N0 n6067 DFFQX1TS
Xfifo_from_fft_fifo_cell5_register_sr_reg[8] fifo_from_fft_fifo_cell5_sr_out[8]
+ clk__L1_N0 n6068 DFFQX1TS
Xfifo_from_fft_fifo_cell5_register_sr_reg[7] fifo_from_fft_fifo_cell5_sr_out[7]
+ clk__L1_N0 n6069 DFFQX1TS
Xfifo_from_fft_fifo_cell5_register_sr_reg[6] fifo_from_fft_fifo_cell5_sr_out[6]
+ clk__L1_N0 n6070 DFFQX1TS
Xfifo_from_fft_fifo_cell5_register_sr_reg[5] fifo_from_fft_fifo_cell5_sr_out[5]
+ clk__L1_N0 n6071 DFFQX1TS
Xfifo_from_fft_fifo_cell5_register_sr_reg[4] fifo_from_fft_fifo_cell5_sr_out[4]
+ clk__L1_N0 n6072 DFFQX1TS
Xfifo_from_fft_fifo_cell5_register_sr_reg[3] fifo_from_fft_fifo_cell5_sr_out[3]
+ clk__L1_N0 n6073 DFFQX1TS
Xfifo_from_fft_fifo_cell5_register_sr_reg[2] fifo_from_fft_fifo_cell5_sr_out[2]
+ clk__L1_N0 n6074 DFFQX1TS
Xfifo_from_fft_fifo_cell5_register_sr_reg[1] fifo_from_fft_fifo_cell5_sr_out[1]
+ clk__L1_N0 n6075 DFFQX1TS
Xfifo_from_fft_fifo_cell5_register_sr_reg[0] fifo_from_fft_fifo_cell5_sr_out[0]
+ clk__L1_N0 n6076 DFFQX1TS
Xfifo_from_fft_fifo_cell6_register_sr_reg[31]
+ fifo_from_fft_fifo_cell6_sr_out[31] clk__L1_N0 n6011 DFFQX1TS
Xfifo_from_fft_fifo_cell6_register_sr_reg[30]
+ fifo_from_fft_fifo_cell6_sr_out[30] clk__L1_N0 n6012 DFFQX1TS
Xfifo_from_fft_fifo_cell6_register_sr_reg[29]
+ fifo_from_fft_fifo_cell6_sr_out[29] clk__L1_N0 n6013 DFFQX1TS
Xfifo_from_fft_fifo_cell6_register_sr_reg[28]
+ fifo_from_fft_fifo_cell6_sr_out[28] clk__L1_N0 n6014 DFFQX1TS
Xfifo_from_fft_fifo_cell6_register_sr_reg[27]
+ fifo_from_fft_fifo_cell6_sr_out[27] clk__L1_N0 n6015 DFFQX1TS
Xfifo_from_fft_fifo_cell6_register_sr_reg[26]
+ fifo_from_fft_fifo_cell6_sr_out[26] clk__L1_N0 n6016 DFFQX1TS
Xfifo_from_fft_fifo_cell6_register_sr_reg[25]
+ fifo_from_fft_fifo_cell6_sr_out[25] clk__L1_N0 n6017 DFFQX1TS
Xfifo_from_fft_fifo_cell6_register_sr_reg[24]
+ fifo_from_fft_fifo_cell6_sr_out[24] clk__L1_N0 n6018 DFFQX1TS
Xfifo_from_fft_fifo_cell6_register_sr_reg[23]
+ fifo_from_fft_fifo_cell6_sr_out[23] clk__L1_N0 n6019 DFFQX1TS
Xfifo_from_fft_fifo_cell6_register_sr_reg[22]
+ fifo_from_fft_fifo_cell6_sr_out[22] clk__L1_N0 n6020 DFFQX1TS
Xfifo_from_fft_fifo_cell6_register_sr_reg[21]
+ fifo_from_fft_fifo_cell6_sr_out[21] clk__L1_N0 n6021 DFFQX1TS
Xfifo_from_fft_fifo_cell6_register_sr_reg[20]
+ fifo_from_fft_fifo_cell6_sr_out[20] clk__L1_N0 n6022 DFFQX1TS
Xfifo_from_fft_fifo_cell6_register_sr_reg[19]
+ fifo_from_fft_fifo_cell6_sr_out[19] clk__L1_N0 n6023 DFFQX1TS
Xfifo_from_fft_fifo_cell6_register_sr_reg[18]
+ fifo_from_fft_fifo_cell6_sr_out[18] clk__L1_N0 n6024 DFFQX1TS
Xfifo_from_fft_fifo_cell6_register_sr_reg[17]
+ fifo_from_fft_fifo_cell6_sr_out[17] clk__L1_N0 n6025 DFFQX1TS
Xfifo_from_fft_fifo_cell6_register_sr_reg[16]
+ fifo_from_fft_fifo_cell6_sr_out[16] clk__L1_N0 n6026 DFFQX1TS
Xfifo_from_fft_fifo_cell6_register_sr_reg[15]
+ fifo_from_fft_fifo_cell6_sr_out[15] clk__L1_N0 n6027 DFFQX1TS
Xfifo_from_fft_fifo_cell6_register_sr_reg[14]
+ fifo_from_fft_fifo_cell6_sr_out[14] clk__L1_N0 n6028 DFFQX1TS
Xfifo_from_fft_fifo_cell6_register_sr_reg[13]
+ fifo_from_fft_fifo_cell6_sr_out[13] clk__L1_N0 n6029 DFFQX1TS
Xfifo_from_fft_fifo_cell6_register_sr_reg[12]
+ fifo_from_fft_fifo_cell6_sr_out[12] clk__L1_N0 n6030 DFFQX1TS
Xfifo_from_fft_fifo_cell6_register_sr_reg[11]
+ fifo_from_fft_fifo_cell6_sr_out[11] clk__L1_N0 n6031 DFFQX1TS
Xfifo_from_fft_fifo_cell6_register_sr_reg[10]
+ fifo_from_fft_fifo_cell6_sr_out[10] clk__L1_N0 n6032 DFFQX1TS
Xfifo_from_fft_fifo_cell6_register_sr_reg[9] fifo_from_fft_fifo_cell6_sr_out[9]
+ clk__L1_N0 n6033 DFFQX1TS
Xfifo_from_fft_fifo_cell6_register_sr_reg[8] fifo_from_fft_fifo_cell6_sr_out[8]
+ clk__L1_N0 n6034 DFFQX1TS
Xfifo_from_fft_fifo_cell6_register_sr_reg[7] fifo_from_fft_fifo_cell6_sr_out[7]
+ clk__L1_N0 n6035 DFFQX1TS
Xfifo_from_fft_fifo_cell6_register_sr_reg[6] fifo_from_fft_fifo_cell6_sr_out[6]
+ clk__L1_N0 n6036 DFFQX1TS
Xfifo_from_fft_fifo_cell6_register_sr_reg[5] fifo_from_fft_fifo_cell6_sr_out[5]
+ clk__L1_N0 n6037 DFFQX1TS
Xfifo_from_fft_fifo_cell6_register_sr_reg[4] fifo_from_fft_fifo_cell6_sr_out[4]
+ clk__L1_N0 n6038 DFFQX1TS
Xfifo_from_fft_fifo_cell6_register_sr_reg[3] fifo_from_fft_fifo_cell6_sr_out[3]
+ clk__L1_N0 n6039 DFFQX1TS
Xfifo_from_fft_fifo_cell6_register_sr_reg[2] fifo_from_fft_fifo_cell6_sr_out[2]
+ clk__L1_N0 n6040 DFFQX1TS
Xfifo_from_fft_fifo_cell6_register_sr_reg[1] fifo_from_fft_fifo_cell6_sr_out[1]
+ clk__L1_N0 n6041 DFFQX1TS
Xfifo_from_fft_fifo_cell6_register_sr_reg[0] fifo_from_fft_fifo_cell6_sr_out[0]
+ clk__L1_N0 n6042 DFFQX1TS
Xfifo_from_fft_fifo_cell7_register_sr_reg[31]
+ fifo_from_fft_fifo_cell7_sr_out[31] clk__L1_N0 n5977 DFFQX1TS
Xfifo_from_fft_fifo_cell7_register_sr_reg[30]
+ fifo_from_fft_fifo_cell7_sr_out[30] clk__L1_N0 n5978 DFFQX1TS
Xfifo_from_fft_fifo_cell7_register_sr_reg[29]
+ fifo_from_fft_fifo_cell7_sr_out[29] clk__L1_N0 n5979 DFFQX1TS
Xfifo_from_fft_fifo_cell7_register_sr_reg[28]
+ fifo_from_fft_fifo_cell7_sr_out[28] clk__L1_N0 n5980 DFFQX1TS
Xfifo_from_fft_fifo_cell7_register_sr_reg[27]
+ fifo_from_fft_fifo_cell7_sr_out[27] clk__L1_N0 n5981 DFFQX1TS
Xfifo_from_fft_fifo_cell7_register_sr_reg[26]
+ fifo_from_fft_fifo_cell7_sr_out[26] clk__L1_N0 n5982 DFFQX1TS
Xfifo_from_fft_fifo_cell7_register_sr_reg[25]
+ fifo_from_fft_fifo_cell7_sr_out[25] clk__L1_N0 n5983 DFFQX1TS
Xfifo_from_fft_fifo_cell7_register_sr_reg[24]
+ fifo_from_fft_fifo_cell7_sr_out[24] clk__L1_N0 n5984 DFFQX1TS
Xfifo_from_fft_fifo_cell7_register_sr_reg[23]
+ fifo_from_fft_fifo_cell7_sr_out[23] clk__L1_N0 n5985 DFFQX1TS
Xfifo_from_fft_fifo_cell7_register_sr_reg[22]
+ fifo_from_fft_fifo_cell7_sr_out[22] clk__L1_N0 n5986 DFFQX1TS
Xfifo_from_fft_fifo_cell7_register_sr_reg[21]
+ fifo_from_fft_fifo_cell7_sr_out[21] clk__L1_N0 n5987 DFFQX1TS
Xfifo_from_fft_fifo_cell7_register_sr_reg[20]
+ fifo_from_fft_fifo_cell7_sr_out[20] clk__L1_N0 n5988 DFFQX1TS
Xfifo_from_fft_fifo_cell7_register_sr_reg[19]
+ fifo_from_fft_fifo_cell7_sr_out[19] clk__L1_N0 n5989 DFFQX1TS
Xfifo_from_fft_fifo_cell7_register_sr_reg[18]
+ fifo_from_fft_fifo_cell7_sr_out[18] clk__L1_N0 n5990 DFFQX1TS
Xfifo_from_fft_fifo_cell7_register_sr_reg[17]
+ fifo_from_fft_fifo_cell7_sr_out[17] clk__L1_N0 n5991 DFFQX1TS
Xfifo_from_fft_fifo_cell7_register_sr_reg[16]
+ fifo_from_fft_fifo_cell7_sr_out[16] clk__L1_N0 n5992 DFFQX1TS
Xfifo_from_fft_fifo_cell7_register_sr_reg[15]
+ fifo_from_fft_fifo_cell7_sr_out[15] clk__L1_N0 n5993 DFFQX1TS
Xfifo_from_fft_fifo_cell7_register_sr_reg[14]
+ fifo_from_fft_fifo_cell7_sr_out[14] clk__L1_N0 n5994 DFFQX1TS
Xfifo_from_fft_fifo_cell7_register_sr_reg[13]
+ fifo_from_fft_fifo_cell7_sr_out[13] clk__L1_N0 n5995 DFFQX1TS
Xfifo_from_fft_fifo_cell7_register_sr_reg[12]
+ fifo_from_fft_fifo_cell7_sr_out[12] clk__L1_N0 n5996 DFFQX1TS
Xfifo_from_fft_fifo_cell7_register_sr_reg[11]
+ fifo_from_fft_fifo_cell7_sr_out[11] clk__L1_N0 n5997 DFFQX1TS
Xfifo_from_fft_fifo_cell7_register_sr_reg[10]
+ fifo_from_fft_fifo_cell7_sr_out[10] clk__L1_N0 n5998 DFFQX1TS
Xfifo_from_fft_fifo_cell7_register_sr_reg[9] fifo_from_fft_fifo_cell7_sr_out[9]
+ clk__L1_N0 n5999 DFFQX1TS
Xfifo_from_fft_fifo_cell7_register_sr_reg[8] fifo_from_fft_fifo_cell7_sr_out[8]
+ clk__L1_N0 n6000 DFFQX1TS
Xfifo_from_fft_fifo_cell7_register_sr_reg[7] fifo_from_fft_fifo_cell7_sr_out[7]
+ clk__L1_N0 n6001 DFFQX1TS
Xfifo_from_fft_fifo_cell7_register_sr_reg[6] fifo_from_fft_fifo_cell7_sr_out[6]
+ clk__L1_N0 n6002 DFFQX1TS
Xfifo_from_fft_fifo_cell7_register_sr_reg[5] fifo_from_fft_fifo_cell7_sr_out[5]
+ clk__L1_N0 n6003 DFFQX1TS
Xfifo_from_fft_fifo_cell7_register_sr_reg[4] fifo_from_fft_fifo_cell7_sr_out[4]
+ clk__L1_N0 n6004 DFFQX1TS
Xfifo_from_fft_fifo_cell7_register_sr_reg[3] fifo_from_fft_fifo_cell7_sr_out[3]
+ clk__L1_N0 n6005 DFFQX1TS
Xfifo_from_fft_fifo_cell7_register_sr_reg[2] fifo_from_fft_fifo_cell7_sr_out[2]
+ clk__L1_N0 n6006 DFFQX1TS
Xfifo_from_fft_fifo_cell7_register_sr_reg[1] fifo_from_fft_fifo_cell7_sr_out[1]
+ clk__L1_N0 n6007 DFFQX1TS
Xfifo_from_fft_fifo_cell7_register_sr_reg[0] fifo_from_fft_fifo_cell7_sr_out[0]
+ clk__L1_N0 n6008 DFFQX1TS
Xfifo_from_fft_fifo_cell8_register_sr_reg[31]
+ fifo_from_fft_fifo_cell8_sr_out[31] clk__L1_N0 n5943 DFFQX1TS
Xfifo_from_fft_fifo_cell8_register_sr_reg[30]
+ fifo_from_fft_fifo_cell8_sr_out[30] clk__L1_N0 n5944 DFFQX1TS
Xfifo_from_fft_fifo_cell8_register_sr_reg[29]
+ fifo_from_fft_fifo_cell8_sr_out[29] clk__L1_N0 n5945 DFFQX1TS
Xfifo_from_fft_fifo_cell8_register_sr_reg[28]
+ fifo_from_fft_fifo_cell8_sr_out[28] clk__L1_N0 n5946 DFFQX1TS
Xfifo_from_fft_fifo_cell8_register_sr_reg[27]
+ fifo_from_fft_fifo_cell8_sr_out[27] clk__L1_N0 n5947 DFFQX1TS
Xfifo_from_fft_fifo_cell8_register_sr_reg[26]
+ fifo_from_fft_fifo_cell8_sr_out[26] clk__L1_N0 n5948 DFFQX1TS
Xfifo_from_fft_fifo_cell8_register_sr_reg[25]
+ fifo_from_fft_fifo_cell8_sr_out[25] clk__L1_N0 n5949 DFFQX1TS
Xfifo_from_fft_fifo_cell8_register_sr_reg[24]
+ fifo_from_fft_fifo_cell8_sr_out[24] clk__L1_N0 n5950 DFFQX1TS
Xfifo_from_fft_fifo_cell8_register_sr_reg[23]
+ fifo_from_fft_fifo_cell8_sr_out[23] clk__L1_N0 n5951 DFFQX1TS
Xfifo_from_fft_fifo_cell8_register_sr_reg[22]
+ fifo_from_fft_fifo_cell8_sr_out[22] clk__L1_N0 n5952 DFFQX1TS
Xfifo_from_fft_fifo_cell8_register_sr_reg[21]
+ fifo_from_fft_fifo_cell8_sr_out[21] clk__L1_N0 n5953 DFFQX1TS
Xfifo_from_fft_fifo_cell8_register_sr_reg[20]
+ fifo_from_fft_fifo_cell8_sr_out[20] clk__L1_N0 n5954 DFFQX1TS
Xfifo_from_fft_fifo_cell8_register_sr_reg[19]
+ fifo_from_fft_fifo_cell8_sr_out[19] clk__L1_N0 n5955 DFFQX1TS
Xfifo_from_fft_fifo_cell8_register_sr_reg[18]
+ fifo_from_fft_fifo_cell8_sr_out[18] clk__L1_N0 n5956 DFFQX1TS
Xfifo_from_fft_fifo_cell8_register_sr_reg[17]
+ fifo_from_fft_fifo_cell8_sr_out[17] clk__L1_N0 n5957 DFFQX1TS
Xfifo_from_fft_fifo_cell8_register_sr_reg[16]
+ fifo_from_fft_fifo_cell8_sr_out[16] clk__L1_N0 n5958 DFFQX1TS
Xfifo_from_fft_fifo_cell8_register_sr_reg[15]
+ fifo_from_fft_fifo_cell8_sr_out[15] clk__L1_N0 n5959 DFFQX1TS
Xfifo_from_fft_fifo_cell8_register_sr_reg[14]
+ fifo_from_fft_fifo_cell8_sr_out[14] clk__L1_N0 n5960 DFFQX1TS
Xfifo_from_fft_fifo_cell8_register_sr_reg[13]
+ fifo_from_fft_fifo_cell8_sr_out[13] clk__L1_N0 n5961 DFFQX1TS
Xfifo_from_fft_fifo_cell8_register_sr_reg[12]
+ fifo_from_fft_fifo_cell8_sr_out[12] clk__L1_N0 n5962 DFFQX1TS
Xfifo_from_fft_fifo_cell8_register_sr_reg[11]
+ fifo_from_fft_fifo_cell8_sr_out[11] clk__L1_N0 n5963 DFFQX1TS
Xfifo_from_fft_fifo_cell8_register_sr_reg[10]
+ fifo_from_fft_fifo_cell8_sr_out[10] clk__L1_N0 n5964 DFFQX1TS
Xfifo_from_fft_fifo_cell8_register_sr_reg[9] fifo_from_fft_fifo_cell8_sr_out[9]
+ clk__L1_N0 n5965 DFFQX1TS
Xfifo_from_fft_fifo_cell8_register_sr_reg[8] fifo_from_fft_fifo_cell8_sr_out[8]
+ clk__L1_N0 n5966 DFFQX1TS
Xfifo_from_fft_fifo_cell8_register_sr_reg[7] fifo_from_fft_fifo_cell8_sr_out[7]
+ clk__L1_N0 n5967 DFFQX1TS
Xfifo_from_fft_fifo_cell8_register_sr_reg[6] fifo_from_fft_fifo_cell8_sr_out[6]
+ clk__L1_N0 n5968 DFFQX1TS
Xfifo_from_fft_fifo_cell8_register_sr_reg[5] fifo_from_fft_fifo_cell8_sr_out[5]
+ clk__L1_N0 n5969 DFFQX1TS
Xfifo_from_fft_fifo_cell8_register_sr_reg[4] fifo_from_fft_fifo_cell8_sr_out[4]
+ clk__L1_N0 n5970 DFFQX1TS
Xfifo_from_fft_fifo_cell8_register_sr_reg[3] fifo_from_fft_fifo_cell8_sr_out[3]
+ clk__L1_N0 n5971 DFFQX1TS
Xfifo_from_fft_fifo_cell8_register_sr_reg[2] fifo_from_fft_fifo_cell8_sr_out[2]
+ clk__L1_N0 n5972 DFFQX1TS
Xfifo_from_fft_fifo_cell8_register_sr_reg[1] fifo_from_fft_fifo_cell8_sr_out[1]
+ clk__L1_N0 n5973 DFFQX1TS
Xfifo_from_fft_fifo_cell8_register_sr_reg[0] fifo_from_fft_fifo_cell8_sr_out[0]
+ clk__L1_N0 n5974 DFFQX1TS
Xfifo_from_fft_fifo_cell9_register_sr_reg[31]
+ fifo_from_fft_fifo_cell9_sr_out[31] clk__L1_N0 n5909 DFFQX1TS
Xfifo_from_fft_fifo_cell9_register_sr_reg[30]
+ fifo_from_fft_fifo_cell9_sr_out[30] clk__L1_N0 n5910 DFFQX1TS
Xfifo_from_fft_fifo_cell9_register_sr_reg[29]
+ fifo_from_fft_fifo_cell9_sr_out[29] clk__L1_N0 n5911 DFFQX1TS
Xfifo_from_fft_fifo_cell9_register_sr_reg[28]
+ fifo_from_fft_fifo_cell9_sr_out[28] clk__L1_N0 n5912 DFFQX1TS
Xfifo_from_fft_fifo_cell9_register_sr_reg[27]
+ fifo_from_fft_fifo_cell9_sr_out[27] clk__L1_N0 n5913 DFFQX1TS
Xfifo_from_fft_fifo_cell9_register_sr_reg[26]
+ fifo_from_fft_fifo_cell9_sr_out[26] clk__L1_N0 n5914 DFFQX1TS
Xfifo_from_fft_fifo_cell9_register_sr_reg[25]
+ fifo_from_fft_fifo_cell9_sr_out[25] clk__L1_N0 n5915 DFFQX1TS
Xfifo_from_fft_fifo_cell9_register_sr_reg[24]
+ fifo_from_fft_fifo_cell9_sr_out[24] clk__L1_N0 n5916 DFFQX1TS
Xfifo_from_fft_fifo_cell9_register_sr_reg[23]
+ fifo_from_fft_fifo_cell9_sr_out[23] clk__L1_N0 n5917 DFFQX1TS
Xfifo_from_fft_fifo_cell9_register_sr_reg[22]
+ fifo_from_fft_fifo_cell9_sr_out[22] clk__L1_N0 n5918 DFFQX1TS
Xfifo_from_fft_fifo_cell9_register_sr_reg[21]
+ fifo_from_fft_fifo_cell9_sr_out[21] clk__L1_N0 n5919 DFFQX1TS
Xfifo_from_fft_fifo_cell9_register_sr_reg[20]
+ fifo_from_fft_fifo_cell9_sr_out[20] clk__L1_N0 n5920 DFFQX1TS
Xfifo_from_fft_fifo_cell9_register_sr_reg[19]
+ fifo_from_fft_fifo_cell9_sr_out[19] clk__L1_N0 n5921 DFFQX1TS
Xfifo_from_fft_fifo_cell9_register_sr_reg[18]
+ fifo_from_fft_fifo_cell9_sr_out[18] clk__L1_N0 n5922 DFFQX1TS
Xfifo_from_fft_fifo_cell9_register_sr_reg[17]
+ fifo_from_fft_fifo_cell9_sr_out[17] clk__L1_N0 n5923 DFFQX1TS
Xfifo_from_fft_fifo_cell9_register_sr_reg[16]
+ fifo_from_fft_fifo_cell9_sr_out[16] clk__L1_N0 n5924 DFFQX1TS
Xfifo_from_fft_fifo_cell9_register_sr_reg[15]
+ fifo_from_fft_fifo_cell9_sr_out[15] clk__L1_N0 n5925 DFFQX1TS
Xfifo_from_fft_fifo_cell9_register_sr_reg[14]
+ fifo_from_fft_fifo_cell9_sr_out[14] clk__L1_N0 n5926 DFFQX1TS
Xfifo_from_fft_fifo_cell9_register_sr_reg[13]
+ fifo_from_fft_fifo_cell9_sr_out[13] clk__L1_N0 n5927 DFFQX1TS
Xfifo_from_fft_fifo_cell9_register_sr_reg[12]
+ fifo_from_fft_fifo_cell9_sr_out[12] clk__L1_N0 n5928 DFFQX1TS
Xfifo_from_fft_fifo_cell9_register_sr_reg[11]
+ fifo_from_fft_fifo_cell9_sr_out[11] clk__L1_N0 n5929 DFFQX1TS
Xfifo_from_fft_fifo_cell9_register_sr_reg[10]
+ fifo_from_fft_fifo_cell9_sr_out[10] clk__L1_N0 n5930 DFFQX1TS
Xfifo_from_fft_fifo_cell9_register_sr_reg[9] fifo_from_fft_fifo_cell9_sr_out[9]
+ clk__L1_N0 n5931 DFFQX1TS
Xfifo_from_fft_fifo_cell9_register_sr_reg[8] fifo_from_fft_fifo_cell9_sr_out[8]
+ clk__L1_N0 n5932 DFFQX1TS
Xfifo_from_fft_fifo_cell9_register_sr_reg[7] fifo_from_fft_fifo_cell9_sr_out[7]
+ clk__L1_N0 n5933 DFFQX1TS
Xfifo_from_fft_fifo_cell9_register_sr_reg[6] fifo_from_fft_fifo_cell9_sr_out[6]
+ clk__L1_N0 n5934 DFFQX1TS
Xfifo_from_fft_fifo_cell9_register_sr_reg[5] fifo_from_fft_fifo_cell9_sr_out[5]
+ clk__L1_N0 n5935 DFFQX1TS
Xfifo_from_fft_fifo_cell9_register_sr_reg[4] fifo_from_fft_fifo_cell9_sr_out[4]
+ clk__L1_N0 n5936 DFFQX1TS
Xfifo_from_fft_fifo_cell9_register_sr_reg[3] fifo_from_fft_fifo_cell9_sr_out[3]
+ clk__L1_N0 n5937 DFFQX1TS
Xfifo_from_fft_fifo_cell9_register_sr_reg[2] fifo_from_fft_fifo_cell9_sr_out[2]
+ clk__L1_N0 n5938 DFFQX1TS
Xfifo_from_fft_fifo_cell9_register_sr_reg[1] fifo_from_fft_fifo_cell9_sr_out[1]
+ clk__L1_N0 n5939 DFFQX1TS
Xfifo_from_fft_fifo_cell9_register_sr_reg[0] fifo_from_fft_fifo_cell9_sr_out[0]
+ clk__L1_N0 n5940 DFFQX1TS
Xfifo_from_fft_fifo_cell10_register_sr_reg[31]
+ fifo_from_fft_fifo_cell10_sr_out[31] clk__L1_N0 n5875 DFFQX1TS
Xfifo_from_fft_fifo_cell10_register_sr_reg[30]
+ fifo_from_fft_fifo_cell10_sr_out[30] clk__L1_N0 n5876 DFFQX1TS
Xfifo_from_fft_fifo_cell10_register_sr_reg[29]
+ fifo_from_fft_fifo_cell10_sr_out[29] clk__L1_N0 n5877 DFFQX1TS
Xfifo_from_fft_fifo_cell10_register_sr_reg[28]
+ fifo_from_fft_fifo_cell10_sr_out[28] clk__L1_N0 n5878 DFFQX1TS
Xfifo_from_fft_fifo_cell10_register_sr_reg[27]
+ fifo_from_fft_fifo_cell10_sr_out[27] clk__L1_N0 n5879 DFFQX1TS
Xfifo_from_fft_fifo_cell10_register_sr_reg[26]
+ fifo_from_fft_fifo_cell10_sr_out[26] clk__L1_N0 n5880 DFFQX1TS
Xfifo_from_fft_fifo_cell10_register_sr_reg[25]
+ fifo_from_fft_fifo_cell10_sr_out[25] clk__L1_N0 n5881 DFFQX1TS
Xfifo_from_fft_fifo_cell10_register_sr_reg[24]
+ fifo_from_fft_fifo_cell10_sr_out[24] clk__L1_N0 n5882 DFFQX1TS
Xfifo_from_fft_fifo_cell10_register_sr_reg[23]
+ fifo_from_fft_fifo_cell10_sr_out[23] clk__L1_N0 n5883 DFFQX1TS
Xfifo_from_fft_fifo_cell10_register_sr_reg[22]
+ fifo_from_fft_fifo_cell10_sr_out[22] clk__L1_N0 n5884 DFFQX1TS
Xfifo_from_fft_fifo_cell10_register_sr_reg[21]
+ fifo_from_fft_fifo_cell10_sr_out[21] clk__L1_N0 n5885 DFFQX1TS
Xfifo_from_fft_fifo_cell10_register_sr_reg[20]
+ fifo_from_fft_fifo_cell10_sr_out[20] clk__L1_N0 n5886 DFFQX1TS
Xfifo_from_fft_fifo_cell10_register_sr_reg[19]
+ fifo_from_fft_fifo_cell10_sr_out[19] clk__L1_N0 n5887 DFFQX1TS
Xfifo_from_fft_fifo_cell10_register_sr_reg[18]
+ fifo_from_fft_fifo_cell10_sr_out[18] clk__L1_N0 n5888 DFFQX1TS
Xfifo_from_fft_fifo_cell10_register_sr_reg[17]
+ fifo_from_fft_fifo_cell10_sr_out[17] clk__L1_N0 n5889 DFFQX1TS
Xfifo_from_fft_fifo_cell10_register_sr_reg[16]
+ fifo_from_fft_fifo_cell10_sr_out[16] clk__L1_N0 n5890 DFFQX1TS
Xfifo_from_fft_fifo_cell10_register_sr_reg[15]
+ fifo_from_fft_fifo_cell10_sr_out[15] clk__L1_N0 n5891 DFFQX1TS
Xfifo_from_fft_fifo_cell10_register_sr_reg[14]
+ fifo_from_fft_fifo_cell10_sr_out[14] clk__L1_N0 n5892 DFFQX1TS
Xfifo_from_fft_fifo_cell10_register_sr_reg[13]
+ fifo_from_fft_fifo_cell10_sr_out[13] clk__L1_N0 n5893 DFFQX1TS
Xfifo_from_fft_fifo_cell10_register_sr_reg[12]
+ fifo_from_fft_fifo_cell10_sr_out[12] clk__L1_N0 n5894 DFFQX1TS
Xfifo_from_fft_fifo_cell10_register_sr_reg[11]
+ fifo_from_fft_fifo_cell10_sr_out[11] clk__L1_N0 n5895 DFFQX1TS
Xfifo_from_fft_fifo_cell10_register_sr_reg[10]
+ fifo_from_fft_fifo_cell10_sr_out[10] clk__L1_N0 n5896 DFFQX1TS
Xfifo_from_fft_fifo_cell10_register_sr_reg[9]
+ fifo_from_fft_fifo_cell10_sr_out[9] clk__L1_N0 n5897 DFFQX1TS
Xfifo_from_fft_fifo_cell10_register_sr_reg[8]
+ fifo_from_fft_fifo_cell10_sr_out[8] clk__L1_N0 n5898 DFFQX1TS
Xfifo_from_fft_fifo_cell10_register_sr_reg[7]
+ fifo_from_fft_fifo_cell10_sr_out[7] clk__L1_N0 n5899 DFFQX1TS
Xfifo_from_fft_fifo_cell10_register_sr_reg[6]
+ fifo_from_fft_fifo_cell10_sr_out[6] clk__L1_N0 n5900 DFFQX1TS
Xfifo_from_fft_fifo_cell10_register_sr_reg[5]
+ fifo_from_fft_fifo_cell10_sr_out[5] clk__L1_N0 n5901 DFFQX1TS
Xfifo_from_fft_fifo_cell10_register_sr_reg[4]
+ fifo_from_fft_fifo_cell10_sr_out[4] clk__L1_N0 n5902 DFFQX1TS
Xfifo_from_fft_fifo_cell10_register_sr_reg[3]
+ fifo_from_fft_fifo_cell10_sr_out[3] clk__L1_N0 n5903 DFFQX1TS
Xfifo_from_fft_fifo_cell10_register_sr_reg[2]
+ fifo_from_fft_fifo_cell10_sr_out[2] clk__L1_N0 n5904 DFFQX1TS
Xfifo_from_fft_fifo_cell10_register_sr_reg[1]
+ fifo_from_fft_fifo_cell10_sr_out[1] clk__L1_N0 n5905 DFFQX1TS
Xfifo_from_fft_fifo_cell10_register_sr_reg[0]
+ fifo_from_fft_fifo_cell10_sr_out[0] clk__L1_N0 n5906 DFFQX1TS
Xfifo_from_fft_fifo_cell11_register_sr_reg[31]
+ fifo_from_fft_fifo_cell11_sr_out[31] clk__L1_N0 n5841 DFFQX1TS
Xfifo_from_fft_fifo_cell11_register_sr_reg[30]
+ fifo_from_fft_fifo_cell11_sr_out[30] clk__L1_N0 n5842 DFFQX1TS
Xfifo_from_fft_fifo_cell11_register_sr_reg[29]
+ fifo_from_fft_fifo_cell11_sr_out[29] clk__L1_N0 n5843 DFFQX1TS
Xfifo_from_fft_fifo_cell11_register_sr_reg[28]
+ fifo_from_fft_fifo_cell11_sr_out[28] clk__L1_N0 n5844 DFFQX1TS
Xfifo_from_fft_fifo_cell11_register_sr_reg[27]
+ fifo_from_fft_fifo_cell11_sr_out[27] clk__L1_N0 n5845 DFFQX1TS
Xfifo_from_fft_fifo_cell11_register_sr_reg[26]
+ fifo_from_fft_fifo_cell11_sr_out[26] clk__L1_N0 n5846 DFFQX1TS
Xfifo_from_fft_fifo_cell11_register_sr_reg[25]
+ fifo_from_fft_fifo_cell11_sr_out[25] clk__L1_N0 n5847 DFFQX1TS
Xfifo_from_fft_fifo_cell11_register_sr_reg[24]
+ fifo_from_fft_fifo_cell11_sr_out[24] clk__L1_N0 n5848 DFFQX1TS
Xfifo_from_fft_fifo_cell11_register_sr_reg[23]
+ fifo_from_fft_fifo_cell11_sr_out[23] clk__L1_N0 n5849 DFFQX1TS
Xfifo_from_fft_fifo_cell11_register_sr_reg[22]
+ fifo_from_fft_fifo_cell11_sr_out[22] clk__L1_N0 n5850 DFFQX1TS
Xfifo_from_fft_fifo_cell11_register_sr_reg[21]
+ fifo_from_fft_fifo_cell11_sr_out[21] clk__L1_N0 n5851 DFFQX1TS
Xfifo_from_fft_fifo_cell11_register_sr_reg[20]
+ fifo_from_fft_fifo_cell11_sr_out[20] clk__L1_N0 n5852 DFFQX1TS
Xfifo_from_fft_fifo_cell11_register_sr_reg[19]
+ fifo_from_fft_fifo_cell11_sr_out[19] clk__L1_N0 n5853 DFFQX1TS
Xfifo_from_fft_fifo_cell11_register_sr_reg[18]
+ fifo_from_fft_fifo_cell11_sr_out[18] clk__L1_N0 n5854 DFFQX1TS
Xfifo_from_fft_fifo_cell11_register_sr_reg[17]
+ fifo_from_fft_fifo_cell11_sr_out[17] clk__L1_N0 n5855 DFFQX1TS
Xfifo_from_fft_fifo_cell11_register_sr_reg[16]
+ fifo_from_fft_fifo_cell11_sr_out[16] clk__L1_N0 n5856 DFFQX1TS
Xfifo_from_fft_fifo_cell11_register_sr_reg[15]
+ fifo_from_fft_fifo_cell11_sr_out[15] clk__L1_N0 n5857 DFFQX1TS
Xfifo_from_fft_fifo_cell11_register_sr_reg[14]
+ fifo_from_fft_fifo_cell11_sr_out[14] clk__L1_N0 n5858 DFFQX1TS
Xfifo_from_fft_fifo_cell11_register_sr_reg[13]
+ fifo_from_fft_fifo_cell11_sr_out[13] clk__L1_N0 n5859 DFFQX1TS
Xfifo_from_fft_fifo_cell11_register_sr_reg[12]
+ fifo_from_fft_fifo_cell11_sr_out[12] clk__L1_N0 n5860 DFFQX1TS
Xfifo_from_fft_fifo_cell11_register_sr_reg[11]
+ fifo_from_fft_fifo_cell11_sr_out[11] clk__L1_N0 n5861 DFFQX1TS
Xfifo_from_fft_fifo_cell11_register_sr_reg[10]
+ fifo_from_fft_fifo_cell11_sr_out[10] clk__L1_N0 n5862 DFFQX1TS
Xfifo_from_fft_fifo_cell11_register_sr_reg[9]
+ fifo_from_fft_fifo_cell11_sr_out[9] clk__L1_N0 n5863 DFFQX1TS
Xfifo_from_fft_fifo_cell11_register_sr_reg[8]
+ fifo_from_fft_fifo_cell11_sr_out[8] clk__L1_N0 n5864 DFFQX1TS
Xfifo_from_fft_fifo_cell11_register_sr_reg[7]
+ fifo_from_fft_fifo_cell11_sr_out[7] clk__L1_N0 n5865 DFFQX1TS
Xfifo_from_fft_fifo_cell11_register_sr_reg[6]
+ fifo_from_fft_fifo_cell11_sr_out[6] clk__L1_N0 n5866 DFFQX1TS
Xfifo_from_fft_fifo_cell11_register_sr_reg[5]
+ fifo_from_fft_fifo_cell11_sr_out[5] clk__L1_N0 n5867 DFFQX1TS
Xfifo_from_fft_fifo_cell11_register_sr_reg[4]
+ fifo_from_fft_fifo_cell11_sr_out[4] clk__L1_N0 n5868 DFFQX1TS
Xfifo_from_fft_fifo_cell11_register_sr_reg[3]
+ fifo_from_fft_fifo_cell11_sr_out[3] clk__L1_N0 n5869 DFFQX1TS
Xfifo_from_fft_fifo_cell11_register_sr_reg[2]
+ fifo_from_fft_fifo_cell11_sr_out[2] clk__L1_N0 n5870 DFFQX1TS
Xfifo_from_fft_fifo_cell11_register_sr_reg[1]
+ fifo_from_fft_fifo_cell11_sr_out[1] clk__L1_N0 n5871 DFFQX1TS
Xfifo_from_fft_fifo_cell11_register_sr_reg[0]
+ fifo_from_fft_fifo_cell11_sr_out[0] clk__L1_N0 n5872 DFFQX1TS
Xfifo_from_fft_fifo_cell12_register_sr_reg[31]
+ fifo_from_fft_fifo_cell12_sr_out[31] clk__L1_N0 n5807 DFFQX1TS
Xfifo_from_fft_fifo_cell12_register_sr_reg[30]
+ fifo_from_fft_fifo_cell12_sr_out[30] clk__L1_N0 n5808 DFFQX1TS
Xfifo_from_fft_fifo_cell12_register_sr_reg[29]
+ fifo_from_fft_fifo_cell12_sr_out[29] clk__L1_N0 n5809 DFFQX1TS
Xfifo_from_fft_fifo_cell12_register_sr_reg[28]
+ fifo_from_fft_fifo_cell12_sr_out[28] clk__L1_N0 n5810 DFFQX1TS
Xfifo_from_fft_fifo_cell12_register_sr_reg[27]
+ fifo_from_fft_fifo_cell12_sr_out[27] clk__L1_N0 n5811 DFFQX1TS
Xfifo_from_fft_fifo_cell12_register_sr_reg[26]
+ fifo_from_fft_fifo_cell12_sr_out[26] clk__L1_N0 n5812 DFFQX1TS
Xfifo_from_fft_fifo_cell12_register_sr_reg[25]
+ fifo_from_fft_fifo_cell12_sr_out[25] clk__L1_N0 n5813 DFFQX1TS
Xfifo_from_fft_fifo_cell12_register_sr_reg[24]
+ fifo_from_fft_fifo_cell12_sr_out[24] clk__L1_N0 n5814 DFFQX1TS
Xfifo_from_fft_fifo_cell12_register_sr_reg[23]
+ fifo_from_fft_fifo_cell12_sr_out[23] clk__L1_N0 n5815 DFFQX1TS
Xfifo_from_fft_fifo_cell12_register_sr_reg[22]
+ fifo_from_fft_fifo_cell12_sr_out[22] clk__L1_N0 n5816 DFFQX1TS
Xfifo_from_fft_fifo_cell12_register_sr_reg[21]
+ fifo_from_fft_fifo_cell12_sr_out[21] clk__L1_N0 n5817 DFFQX1TS
Xfifo_from_fft_fifo_cell12_register_sr_reg[20]
+ fifo_from_fft_fifo_cell12_sr_out[20] clk__L1_N0 n5818 DFFQX1TS
Xfifo_from_fft_fifo_cell12_register_sr_reg[19]
+ fifo_from_fft_fifo_cell12_sr_out[19] clk__L1_N0 n5819 DFFQX1TS
Xfifo_from_fft_fifo_cell12_register_sr_reg[18]
+ fifo_from_fft_fifo_cell12_sr_out[18] clk__L1_N0 n5820 DFFQX1TS
Xfifo_from_fft_fifo_cell12_register_sr_reg[17]
+ fifo_from_fft_fifo_cell12_sr_out[17] clk__L1_N0 n5821 DFFQX1TS
Xfifo_from_fft_fifo_cell12_register_sr_reg[16]
+ fifo_from_fft_fifo_cell12_sr_out[16] clk__L1_N0 n5822 DFFQX1TS
Xfifo_from_fft_fifo_cell12_register_sr_reg[15]
+ fifo_from_fft_fifo_cell12_sr_out[15] clk__L1_N0 n5823 DFFQX1TS
Xfifo_from_fft_fifo_cell12_register_sr_reg[14]
+ fifo_from_fft_fifo_cell12_sr_out[14] clk__L1_N0 n5824 DFFQX1TS
Xfifo_from_fft_fifo_cell12_register_sr_reg[13]
+ fifo_from_fft_fifo_cell12_sr_out[13] clk__L1_N0 n5825 DFFQX1TS
Xfifo_from_fft_fifo_cell12_register_sr_reg[12]
+ fifo_from_fft_fifo_cell12_sr_out[12] clk__L1_N0 n5826 DFFQX1TS
Xfifo_from_fft_fifo_cell12_register_sr_reg[11]
+ fifo_from_fft_fifo_cell12_sr_out[11] clk__L1_N0 n5827 DFFQX1TS
Xfifo_from_fft_fifo_cell12_register_sr_reg[10]
+ fifo_from_fft_fifo_cell12_sr_out[10] clk__L1_N0 n5828 DFFQX1TS
Xfifo_from_fft_fifo_cell12_register_sr_reg[9]
+ fifo_from_fft_fifo_cell12_sr_out[9] clk__L1_N0 n5829 DFFQX1TS
Xfifo_from_fft_fifo_cell12_register_sr_reg[8]
+ fifo_from_fft_fifo_cell12_sr_out[8] clk__L1_N0 n5830 DFFQX1TS
Xfifo_from_fft_fifo_cell12_register_sr_reg[7]
+ fifo_from_fft_fifo_cell12_sr_out[7] clk__L1_N0 n5831 DFFQX1TS
Xfifo_from_fft_fifo_cell12_register_sr_reg[6]
+ fifo_from_fft_fifo_cell12_sr_out[6] clk__L1_N0 n5832 DFFQX1TS
Xfifo_from_fft_fifo_cell12_register_sr_reg[5]
+ fifo_from_fft_fifo_cell12_sr_out[5] clk__L1_N0 n5833 DFFQX1TS
Xfifo_from_fft_fifo_cell12_register_sr_reg[4]
+ fifo_from_fft_fifo_cell12_sr_out[4] clk__L1_N0 n5834 DFFQX1TS
Xfifo_from_fft_fifo_cell12_register_sr_reg[3]
+ fifo_from_fft_fifo_cell12_sr_out[3] clk__L1_N0 n5835 DFFQX1TS
Xfifo_from_fft_fifo_cell12_register_sr_reg[2]
+ fifo_from_fft_fifo_cell12_sr_out[2] clk__L1_N0 n5836 DFFQX1TS
Xfifo_from_fft_fifo_cell12_register_sr_reg[1]
+ fifo_from_fft_fifo_cell12_sr_out[1] clk__L1_N0 n5837 DFFQX1TS
Xfifo_from_fft_fifo_cell12_register_sr_reg[0]
+ fifo_from_fft_fifo_cell12_sr_out[0] clk__L1_N0 n5838 DFFQX1TS
Xfifo_from_fft_fifo_cell13_register_sr_reg[31]
+ fifo_from_fft_fifo_cell13_sr_out[31] clk__L1_N0 n5773 DFFQX1TS
Xfifo_from_fft_fifo_cell13_register_sr_reg[30]
+ fifo_from_fft_fifo_cell13_sr_out[30] clk__L1_N0 n5774 DFFQX1TS
Xfifo_from_fft_fifo_cell13_register_sr_reg[29]
+ fifo_from_fft_fifo_cell13_sr_out[29] clk__L1_N0 n5775 DFFQX1TS
Xfifo_from_fft_fifo_cell13_register_sr_reg[28]
+ fifo_from_fft_fifo_cell13_sr_out[28] clk__L1_N0 n5776 DFFQX1TS
Xfifo_from_fft_fifo_cell13_register_sr_reg[27]
+ fifo_from_fft_fifo_cell13_sr_out[27] clk__L1_N0 n5777 DFFQX1TS
Xfifo_from_fft_fifo_cell13_register_sr_reg[26]
+ fifo_from_fft_fifo_cell13_sr_out[26] clk__L1_N0 n5778 DFFQX1TS
Xfifo_from_fft_fifo_cell13_register_sr_reg[25]
+ fifo_from_fft_fifo_cell13_sr_out[25] clk__L1_N0 n5779 DFFQX1TS
Xfifo_from_fft_fifo_cell13_register_sr_reg[24]
+ fifo_from_fft_fifo_cell13_sr_out[24] clk__L1_N0 n5780 DFFQX1TS
Xfifo_from_fft_fifo_cell13_register_sr_reg[23]
+ fifo_from_fft_fifo_cell13_sr_out[23] clk__L1_N0 n5781 DFFQX1TS
Xfifo_from_fft_fifo_cell13_register_sr_reg[22]
+ fifo_from_fft_fifo_cell13_sr_out[22] clk__L1_N0 n5782 DFFQX1TS
Xfifo_from_fft_fifo_cell13_register_sr_reg[21]
+ fifo_from_fft_fifo_cell13_sr_out[21] clk__L1_N0 n5783 DFFQX1TS
Xfifo_from_fft_fifo_cell13_register_sr_reg[20]
+ fifo_from_fft_fifo_cell13_sr_out[20] clk__L1_N0 n5784 DFFQX1TS
Xfifo_from_fft_fifo_cell13_register_sr_reg[19]
+ fifo_from_fft_fifo_cell13_sr_out[19] clk__L1_N0 n5785 DFFQX1TS
Xfifo_from_fft_fifo_cell13_register_sr_reg[18]
+ fifo_from_fft_fifo_cell13_sr_out[18] clk__L1_N0 n5786 DFFQX1TS
Xfifo_from_fft_fifo_cell13_register_sr_reg[17]
+ fifo_from_fft_fifo_cell13_sr_out[17] clk__L1_N0 n5787 DFFQX1TS
Xfifo_from_fft_fifo_cell13_register_sr_reg[16]
+ fifo_from_fft_fifo_cell13_sr_out[16] clk__L1_N0 n5788 DFFQX1TS
Xfifo_from_fft_fifo_cell13_register_sr_reg[15]
+ fifo_from_fft_fifo_cell13_sr_out[15] clk__L1_N0 n5789 DFFQX1TS
Xfifo_from_fft_fifo_cell13_register_sr_reg[14]
+ fifo_from_fft_fifo_cell13_sr_out[14] clk__L1_N0 n5790 DFFQX1TS
Xfifo_from_fft_fifo_cell13_register_sr_reg[13]
+ fifo_from_fft_fifo_cell13_sr_out[13] clk__L1_N0 n5791 DFFQX1TS
Xfifo_from_fft_fifo_cell13_register_sr_reg[12]
+ fifo_from_fft_fifo_cell13_sr_out[12] clk__L1_N0 n5792 DFFQX1TS
Xfifo_from_fft_fifo_cell13_register_sr_reg[11]
+ fifo_from_fft_fifo_cell13_sr_out[11] clk__L1_N0 n5793 DFFQX1TS
Xfifo_from_fft_fifo_cell13_register_sr_reg[10]
+ fifo_from_fft_fifo_cell13_sr_out[10] clk__L1_N0 n5794 DFFQX1TS
Xfifo_from_fft_fifo_cell13_register_sr_reg[9]
+ fifo_from_fft_fifo_cell13_sr_out[9] clk__L1_N0 n5795 DFFQX1TS
Xfifo_from_fft_fifo_cell13_register_sr_reg[8]
+ fifo_from_fft_fifo_cell13_sr_out[8] clk__L1_N0 n5796 DFFQX1TS
Xfifo_from_fft_fifo_cell13_register_sr_reg[7]
+ fifo_from_fft_fifo_cell13_sr_out[7] clk__L1_N0 n5797 DFFQX1TS
Xfifo_from_fft_fifo_cell13_register_sr_reg[6]
+ fifo_from_fft_fifo_cell13_sr_out[6] clk__L1_N0 n5798 DFFQX1TS
Xfifo_from_fft_fifo_cell13_register_sr_reg[5]
+ fifo_from_fft_fifo_cell13_sr_out[5] clk__L1_N0 n5799 DFFQX1TS
Xfifo_from_fft_fifo_cell13_register_sr_reg[4]
+ fifo_from_fft_fifo_cell13_sr_out[4] clk__L1_N0 n5800 DFFQX1TS
Xfifo_from_fft_fifo_cell13_register_sr_reg[3]
+ fifo_from_fft_fifo_cell13_sr_out[3] clk__L1_N0 n5801 DFFQX1TS
Xfifo_from_fft_fifo_cell13_register_sr_reg[2]
+ fifo_from_fft_fifo_cell13_sr_out[2] clk__L1_N0 n5802 DFFQX1TS
Xfifo_from_fft_fifo_cell13_register_sr_reg[1]
+ fifo_from_fft_fifo_cell13_sr_out[1] clk__L1_N0 n5803 DFFQX1TS
Xfifo_from_fft_fifo_cell13_register_sr_reg[0]
+ fifo_from_fft_fifo_cell13_sr_out[0] clk__L1_N0 n5804 DFFQX1TS
Xfifo_from_fft_fifo_cell14_register_sr_reg[31]
+ fifo_from_fft_fifo_cell14_sr_out[31] clk__L1_N0 n5739 DFFQX1TS
Xfifo_from_fft_fifo_cell14_register_sr_reg[30]
+ fifo_from_fft_fifo_cell14_sr_out[30] clk__L1_N0 n5740 DFFQX1TS
Xfifo_from_fft_fifo_cell14_register_sr_reg[29]
+ fifo_from_fft_fifo_cell14_sr_out[29] clk__L1_N0 n5741 DFFQX1TS
Xfifo_from_fft_fifo_cell14_register_sr_reg[28]
+ fifo_from_fft_fifo_cell14_sr_out[28] clk__L1_N0 n5742 DFFQX1TS
Xfifo_from_fft_fifo_cell14_register_sr_reg[27]
+ fifo_from_fft_fifo_cell14_sr_out[27] clk__L1_N0 n5743 DFFQX1TS
Xfifo_from_fft_fifo_cell14_register_sr_reg[26]
+ fifo_from_fft_fifo_cell14_sr_out[26] clk__L1_N0 n5744 DFFQX1TS
Xfifo_from_fft_fifo_cell14_register_sr_reg[25]
+ fifo_from_fft_fifo_cell14_sr_out[25] clk__L1_N0 n5745 DFFQX1TS
Xfifo_from_fft_fifo_cell14_register_sr_reg[24]
+ fifo_from_fft_fifo_cell14_sr_out[24] clk__L1_N0 n5746 DFFQX1TS
Xfifo_from_fft_fifo_cell14_register_sr_reg[23]
+ fifo_from_fft_fifo_cell14_sr_out[23] clk__L1_N0 n5747 DFFQX1TS
Xfifo_from_fft_fifo_cell14_register_sr_reg[22]
+ fifo_from_fft_fifo_cell14_sr_out[22] clk__L1_N0 n5748 DFFQX1TS
Xfifo_from_fft_fifo_cell14_register_sr_reg[21]
+ fifo_from_fft_fifo_cell14_sr_out[21] clk__L1_N0 n5749 DFFQX1TS
Xfifo_from_fft_fifo_cell14_register_sr_reg[20]
+ fifo_from_fft_fifo_cell14_sr_out[20] clk__L1_N0 n5750 DFFQX1TS
Xfifo_from_fft_fifo_cell14_register_sr_reg[19]
+ fifo_from_fft_fifo_cell14_sr_out[19] clk__L1_N0 n5751 DFFQX1TS
Xfifo_from_fft_fifo_cell14_register_sr_reg[18]
+ fifo_from_fft_fifo_cell14_sr_out[18] clk__L1_N0 n5752 DFFQX1TS
Xfifo_from_fft_fifo_cell14_register_sr_reg[17]
+ fifo_from_fft_fifo_cell14_sr_out[17] clk__L1_N0 n5753 DFFQX1TS
Xfifo_from_fft_fifo_cell14_register_sr_reg[16]
+ fifo_from_fft_fifo_cell14_sr_out[16] clk__L1_N0 n5754 DFFQX1TS
Xfifo_from_fft_fifo_cell14_register_sr_reg[15]
+ fifo_from_fft_fifo_cell14_sr_out[15] clk__L1_N0 n5755 DFFQX1TS
Xfifo_from_fft_fifo_cell14_register_sr_reg[14]
+ fifo_from_fft_fifo_cell14_sr_out[14] clk__L1_N0 n5756 DFFQX1TS
Xfifo_from_fft_fifo_cell14_register_sr_reg[13]
+ fifo_from_fft_fifo_cell14_sr_out[13] clk__L1_N0 n5757 DFFQX1TS
Xfifo_from_fft_fifo_cell14_register_sr_reg[12]
+ fifo_from_fft_fifo_cell14_sr_out[12] clk__L1_N0 n5758 DFFQX1TS
Xfifo_from_fft_fifo_cell14_register_sr_reg[11]
+ fifo_from_fft_fifo_cell14_sr_out[11] clk__L1_N0 n5759 DFFQX1TS
Xfifo_from_fft_fifo_cell14_register_sr_reg[10]
+ fifo_from_fft_fifo_cell14_sr_out[10] clk__L1_N0 n5760 DFFQX1TS
Xfifo_from_fft_fifo_cell14_register_sr_reg[9]
+ fifo_from_fft_fifo_cell14_sr_out[9] clk__L1_N0 n5761 DFFQX1TS
Xfifo_from_fft_fifo_cell14_register_sr_reg[8]
+ fifo_from_fft_fifo_cell14_sr_out[8] clk__L1_N0 n5762 DFFQX1TS
Xfifo_from_fft_fifo_cell14_register_sr_reg[7]
+ fifo_from_fft_fifo_cell14_sr_out[7] clk__L1_N0 n5763 DFFQX1TS
Xfifo_from_fft_fifo_cell14_register_sr_reg[6]
+ fifo_from_fft_fifo_cell14_sr_out[6] clk__L1_N0 n5764 DFFQX1TS
Xfifo_from_fft_fifo_cell14_register_sr_reg[5]
+ fifo_from_fft_fifo_cell14_sr_out[5] clk__L1_N0 n5765 DFFQX1TS
Xfifo_from_fft_fifo_cell14_register_sr_reg[4]
+ fifo_from_fft_fifo_cell14_sr_out[4] clk__L1_N0 n5766 DFFQX1TS
Xfifo_from_fft_fifo_cell14_register_sr_reg[3]
+ fifo_from_fft_fifo_cell14_sr_out[3] clk__L1_N0 n5767 DFFQX1TS
Xfifo_from_fft_fifo_cell14_register_sr_reg[2]
+ fifo_from_fft_fifo_cell14_sr_out[2] clk__L1_N0 n5768 DFFQX1TS
Xfifo_from_fft_fifo_cell14_register_sr_reg[1]
+ fifo_from_fft_fifo_cell14_sr_out[1] clk__L1_N0 n5769 DFFQX1TS
Xfifo_from_fft_fifo_cell14_register_sr_reg[0]
+ fifo_from_fft_fifo_cell14_sr_out[0] clk__L1_N0 n5770 DFFQX1TS
Xfifo_from_fft_fifo_cell15_register_sr_reg[31]
+ fifo_from_fft_fifo_cell15_sr_out[31] clk__L1_N0 n5705 DFFQX1TS
Xfifo_from_fft_fifo_cell15_register_sr_reg[30]
+ fifo_from_fft_fifo_cell15_sr_out[30] clk__L1_N0 n5706 DFFQX1TS
Xfifo_from_fft_fifo_cell15_register_sr_reg[29]
+ fifo_from_fft_fifo_cell15_sr_out[29] clk__L1_N0 n5707 DFFQX1TS
Xfifo_from_fft_fifo_cell15_register_sr_reg[28]
+ fifo_from_fft_fifo_cell15_sr_out[28] clk__L1_N0 n5708 DFFQX1TS
Xfifo_from_fft_fifo_cell15_register_sr_reg[27]
+ fifo_from_fft_fifo_cell15_sr_out[27] clk__L1_N0 n5709 DFFQX1TS
Xfifo_from_fft_fifo_cell15_register_sr_reg[26]
+ fifo_from_fft_fifo_cell15_sr_out[26] clk__L1_N0 n5710 DFFQX1TS
Xfifo_from_fft_fifo_cell15_register_sr_reg[25]
+ fifo_from_fft_fifo_cell15_sr_out[25] clk__L1_N0 n5711 DFFQX1TS
Xfifo_from_fft_fifo_cell15_register_sr_reg[24]
+ fifo_from_fft_fifo_cell15_sr_out[24] clk__L1_N0 n5712 DFFQX1TS
Xfifo_from_fft_fifo_cell15_register_sr_reg[23]
+ fifo_from_fft_fifo_cell15_sr_out[23] clk__L1_N0 n5713 DFFQX1TS
Xfifo_from_fft_fifo_cell15_register_sr_reg[22]
+ fifo_from_fft_fifo_cell15_sr_out[22] clk__L1_N0 n5714 DFFQX1TS
Xfifo_from_fft_fifo_cell15_register_sr_reg[21]
+ fifo_from_fft_fifo_cell15_sr_out[21] clk__L1_N0 n5715 DFFQX1TS
Xfifo_from_fft_fifo_cell15_register_sr_reg[20]
+ fifo_from_fft_fifo_cell15_sr_out[20] clk__L1_N0 n5716 DFFQX1TS
Xfifo_from_fft_fifo_cell15_register_sr_reg[19]
+ fifo_from_fft_fifo_cell15_sr_out[19] clk__L1_N0 n5717 DFFQX1TS
Xfifo_from_fft_fifo_cell15_register_sr_reg[18]
+ fifo_from_fft_fifo_cell15_sr_out[18] clk__L1_N0 n5718 DFFQX1TS
Xfifo_from_fft_fifo_cell15_register_sr_reg[17]
+ fifo_from_fft_fifo_cell15_sr_out[17] clk__L1_N0 n5719 DFFQX1TS
Xfifo_from_fft_fifo_cell15_register_sr_reg[16]
+ fifo_from_fft_fifo_cell15_sr_out[16] clk__L1_N0 n5720 DFFQX1TS
Xfifo_from_fft_fifo_cell15_register_sr_reg[15]
+ fifo_from_fft_fifo_cell15_sr_out[15] clk__L1_N0 n5721 DFFQX1TS
Xfifo_from_fft_fifo_cell15_register_sr_reg[14]
+ fifo_from_fft_fifo_cell15_sr_out[14] clk__L1_N0 n5722 DFFQX1TS
Xfifo_from_fft_fifo_cell15_register_sr_reg[13]
+ fifo_from_fft_fifo_cell15_sr_out[13] clk__L1_N0 n5723 DFFQX1TS
Xfifo_from_fft_fifo_cell15_register_sr_reg[12]
+ fifo_from_fft_fifo_cell15_sr_out[12] clk__L1_N0 n5724 DFFQX1TS
Xfifo_from_fft_fifo_cell15_register_sr_reg[11]
+ fifo_from_fft_fifo_cell15_sr_out[11] clk__L1_N0 n5725 DFFQX1TS
Xfifo_from_fft_fifo_cell15_register_sr_reg[10]
+ fifo_from_fft_fifo_cell15_sr_out[10] clk__L1_N0 n5726 DFFQX1TS
Xfifo_from_fft_fifo_cell15_register_sr_reg[9]
+ fifo_from_fft_fifo_cell15_sr_out[9] clk__L1_N0 n5727 DFFQX1TS
Xfifo_from_fft_fifo_cell15_register_sr_reg[8]
+ fifo_from_fft_fifo_cell15_sr_out[8] clk__L1_N0 n5728 DFFQX1TS
Xfifo_from_fft_fifo_cell15_register_sr_reg[7]
+ fifo_from_fft_fifo_cell15_sr_out[7] clk__L1_N0 n5729 DFFQX1TS
Xfifo_from_fft_fifo_cell15_register_sr_reg[6]
+ fifo_from_fft_fifo_cell15_sr_out[6] clk__L1_N0 n5730 DFFQX1TS
Xfifo_from_fft_fifo_cell15_register_sr_reg[5]
+ fifo_from_fft_fifo_cell15_sr_out[5] clk__L1_N0 n5731 DFFQX1TS
Xfifo_from_fft_fifo_cell15_register_sr_reg[4]
+ fifo_from_fft_fifo_cell15_sr_out[4] clk__L1_N0 n5732 DFFQX1TS
Xfifo_from_fft_fifo_cell15_register_sr_reg[3]
+ fifo_from_fft_fifo_cell15_sr_out[3] clk__L1_N0 n5733 DFFQX1TS
Xfifo_from_fft_fifo_cell15_register_sr_reg[2]
+ fifo_from_fft_fifo_cell15_sr_out[2] clk__L1_N0 n5734 DFFQX1TS
Xfifo_from_fft_fifo_cell15_register_sr_reg[1]
+ fifo_from_fft_fifo_cell15_sr_out[1] clk__L1_N0 n5735 DFFQX1TS
Xfifo_from_fft_fifo_cell15_register_sr_reg[0]
+ fifo_from_fft_fifo_cell15_sr_out[0] clk__L1_N0 n5736 DFFQX1TS
Xfifo_from_fir_fifo_cell0_controller_write_enable_reg 1190
+ fifo_from_fir_fifo_cell0_controller_write_enable clk__L1_N0 n7216
+ fifo_from_fir_fifo_cell0_controller_valid_read n9546 EDFFTRX1TS
Xfifo_from_fft_fifo_cell0_controller_write_enable_reg 1191
+ fifo_from_fft_fifo_cell0_controller_write_enable clk__L1_N0 n7221
+ fifo_from_fft_fifo_cell0_controller_valid_read n9546 EDFFTRX1TS
Xrouter_pla_top_instruction_valid_reg router_pla_top_instruction_valid
+ clk__L1_N0 router_pla_top_N60 DFFQX1TS
Xfifo_from_fir_fifo_cell15_reg_gtok_token_reg
+ fifo_from_fir_fifo_cell15_reg_gtok_token clk__L1_N0 n6745 DFFQX1TS
Xfifo_from_fft_fifo_cell15_reg_gtok_token_reg
+ fifo_from_fft_fifo_cell15_reg_gtok_token clk__L1_N0 n6216 DFFQX1TS
Xfifo_to_fft_fifo_cell15_reg_gtok_token_reg
+ fifo_to_fft_fifo_cell15_reg_gtok_token clk__L1_N0 n5469 DFFQX1TS
Xfifo_to_fir_fifo_cell15_reg_gtok_token_reg
+ fifo_to_fir_fifo_cell15_reg_gtok_token clk__L1_N0 n5521 DFFQX1TS
Xfifo_to_fft_fifo_cell0_controller_valid_read_reg
+ fifo_to_fft_fifo_cell0_controller_valid_read clk__L1_N0 n9515 DFFQX1TS
Xfifo_to_fir_fifo_cell0_controller_valid_read_reg
+ fifo_to_fir_fifo_cell0_controller_valid_read clk__L1_N0 n9524 DFFQX1TS
Xfifo_from_fft_fifo_cell0_controller_valid_read_reg
+ fifo_from_fft_fifo_cell0_controller_valid_read clk__L1_N0 n9520 DFFQX1TS
Xfifo_from_fir_fifo_cell0_controller_valid_read_reg
+ fifo_from_fir_fifo_cell0_controller_valid_read clk__L1_N0 n9528 DFFQX1TS
Xfifo_to_fft_fifo_cell15_reg_ptok_token_reg fifo_to_fft_hang[14] clk__L1_N0
+ n5516 DFFQX1TS
Xfifo_to_fir_fifo_cell15_reg_ptok_token_reg fifo_to_fir_hang[14] clk__L1_N0
+ n5568 DFFQX1TS
Xrouter_addr_calc_iir_write_calc_counter_hold_reg
+ router_addr_calc_iir_write_calc_counter_hold clk__L1_N0 n6766 DFFQX1TS
Xrouter_addr_calc_fir_read_calc_counter_hold_reg
+ router_addr_calc_fir_read_calc_counter_hold clk__L1_N0 n5572 DFFQX1TS
Xrouter_addr_calc_fir_write_calc_counter_hold_reg
+ router_addr_calc_fir_write_calc_counter_hold clk__L1_N0 n5520 DFFQX1TS
Xrouter_addr_calc_fft_read_calc_counter_hold_reg
+ router_addr_calc_fft_read_calc_counter_hold clk__L1_N0 n5457 DFFQX1TS
Xrouter_addr_calc_fft_write_calc_counter_hold_reg
+ router_addr_calc_fft_write_calc_counter_hold clk__L1_N0 n5468 DFFQX1TS
Xfifo_from_fir_fifo_cell0_data_out_en_reg fifo_from_fir_fifo_cell0_data_out_N9
+ clk__L1_N0 n4766 DFFQX1TS
Xfifo_from_fft_fifo_cell0_data_out_en_reg fifo_from_fft_fifo_cell0_data_out_N9
+ clk__L1_N0 n4580 DFFQX1TS
Xfifo_from_fir_fifo_cell14_data_out_en_reg n8093
+ fifo_from_fir_fifo_cell14_data_out_N9 clk__L1_N0 FE_OFN735_n4829
+ fifo_from_fir_fifo_cell13_reg_gtok_token DFFTRX2TS
Xfifo_from_fir_fifo_cell13_data_out_en_reg n8092
+ fifo_from_fir_fifo_cell13_data_out_N9 clk__L1_N0 FE_OFN736_n4829
+ fifo_from_fir_fifo_cell12_reg_gtok_token DFFTRX2TS
Xfifo_from_fir_fifo_cell12_data_out_en_reg n8091
+ fifo_from_fir_fifo_cell12_data_out_N9 clk__L1_N0 FE_OFN736_n4829
+ fifo_from_fir_fifo_cell11_reg_gtok_token DFFTRX2TS
Xfifo_from_fir_fifo_cell11_data_out_en_reg n8090
+ fifo_from_fir_fifo_cell11_data_out_N9 clk__L1_N0 FE_OFN739_n4829
+ fifo_from_fir_fifo_cell10_reg_gtok_token DFFTRX2TS
Xfifo_from_fir_fifo_cell10_data_out_en_reg n8089
+ fifo_from_fir_fifo_cell10_data_out_N9 clk__L1_N0 FE_OFN737_n4829
+ fifo_from_fir_fifo_cell9_reg_gtok_token DFFTRX2TS
Xfifo_from_fir_fifo_cell9_data_out_en_reg n8088
+ fifo_from_fir_fifo_cell9_data_out_N9 clk__L1_N0 FE_OFN744_n4829
+ fifo_from_fir_fifo_cell8_reg_gtok_token DFFTRX2TS
Xfifo_from_fir_fifo_cell8_data_out_en_reg n8087
+ fifo_from_fir_fifo_cell8_data_out_N9 clk__L1_N0 FE_OFN744_n4829
+ fifo_from_fir_fifo_cell7_reg_gtok_token DFFTRX2TS
Xfifo_from_fir_fifo_cell7_data_out_en_reg n8086
+ fifo_from_fir_fifo_cell7_data_out_N9 clk__L1_N0 FE_OFN743_n4829
+ fifo_from_fir_fifo_cell6_reg_gtok_token DFFTRX2TS
Xfifo_from_fir_fifo_cell6_data_out_en_reg n8085
+ fifo_from_fir_fifo_cell6_data_out_N9 clk__L1_N0 FE_OFN740_n4829
+ fifo_from_fir_fifo_cell5_reg_gtok_token DFFTRX2TS
Xfifo_from_fir_fifo_cell5_data_out_en_reg n8084
+ fifo_from_fir_fifo_cell5_data_out_N9 clk__L1_N0 FE_OFN740_n4829
+ fifo_from_fir_fifo_cell4_reg_gtok_token DFFTRX2TS
Xfifo_from_fir_fifo_cell4_data_out_en_reg n8083
+ fifo_from_fir_fifo_cell4_data_out_N9 clk__L1_N0 FE_OFN738_n4829
+ fifo_from_fir_fifo_cell3_reg_gtok_token DFFTRX2TS
Xfifo_from_fir_fifo_cell3_data_out_en_reg n8082
+ fifo_from_fir_fifo_cell3_data_out_N9 clk__L1_N0 FE_OFN736_n4829
+ fifo_from_fir_fifo_cell2_reg_gtok_token DFFTRX2TS
Xfifo_from_fir_fifo_cell2_data_out_en_reg n8081
+ fifo_from_fir_fifo_cell2_data_out_N9 clk__L1_N0 n4829
+ fifo_from_fir_fifo_cell1_reg_gtok_token DFFTRX2TS
Xfifo_from_fir_fifo_cell1_data_out_en_reg n8080
+ fifo_from_fir_fifo_cell1_data_out_N9 clk__L1_N0 FE_OFN735_n4829
+ fifo_from_fir_fifo_cell0_reg_gtok_token DFFTRX2TS
Xfifo_from_fft_fifo_cell14_data_out_en_reg n8078
+ fifo_from_fft_fifo_cell14_data_out_N9 clk__L1_N0 FE_OFN723_n4643
+ fifo_from_fft_fifo_cell13_reg_gtok_token DFFTRX2TS
Xfifo_from_fft_fifo_cell13_data_out_en_reg n8077
+ fifo_from_fft_fifo_cell13_data_out_N9 clk__L1_N0 FE_OFN722_n4643
+ fifo_from_fft_fifo_cell12_reg_gtok_token DFFTRX2TS
Xfifo_from_fft_fifo_cell12_data_out_en_reg n8076
+ fifo_from_fft_fifo_cell12_data_out_N9 clk__L1_N0 FE_OFN728_n4643
+ fifo_from_fft_fifo_cell11_reg_gtok_token DFFTRX2TS
Xfifo_from_fft_fifo_cell11_data_out_en_reg n8075
+ fifo_from_fft_fifo_cell11_data_out_N9 clk__L1_N0 FE_OFN725_n4643
+ fifo_from_fft_fifo_cell10_reg_gtok_token DFFTRX2TS
Xfifo_from_fft_fifo_cell10_data_out_en_reg n8074
+ fifo_from_fft_fifo_cell10_data_out_N9 clk__L1_N0 FE_OFN726_n4643
+ fifo_from_fft_fifo_cell9_reg_gtok_token DFFTRX2TS
Xfifo_from_fft_fifo_cell9_data_out_en_reg n8073
+ fifo_from_fft_fifo_cell9_data_out_N9 clk__L1_N0 FE_OFN728_n4643
+ fifo_from_fft_fifo_cell8_reg_gtok_token DFFTRX2TS
Xfifo_from_fft_fifo_cell8_data_out_en_reg n8072
+ fifo_from_fft_fifo_cell8_data_out_N9 clk__L1_N0 FE_OFN727_n4643
+ fifo_from_fft_fifo_cell7_reg_gtok_token DFFTRX2TS
Xfifo_from_fft_fifo_cell7_data_out_en_reg n8071
+ fifo_from_fft_fifo_cell7_data_out_N9 clk__L1_N0 FE_OFN722_n4643
+ fifo_from_fft_fifo_cell6_reg_gtok_token DFFTRX2TS
Xfifo_from_fft_fifo_cell6_data_out_en_reg n8070
+ fifo_from_fft_fifo_cell6_data_out_N9 clk__L1_N0 FE_OFN1822_n4643
+ fifo_from_fft_fifo_cell5_reg_gtok_token DFFTRX2TS
Xfifo_from_fft_fifo_cell5_data_out_en_reg n8069
+ fifo_from_fft_fifo_cell5_data_out_N9 clk__L1_N0 FE_OFN1822_n4643
+ fifo_from_fft_fifo_cell4_reg_gtok_token DFFTRX2TS
Xfifo_from_fft_fifo_cell4_data_out_en_reg n8068
+ fifo_from_fft_fifo_cell4_data_out_N9 clk__L1_N0 FE_OFN1823_n4643
+ fifo_from_fft_fifo_cell3_reg_gtok_token DFFTRX2TS
Xfifo_from_fft_fifo_cell3_data_out_en_reg n8067
+ fifo_from_fft_fifo_cell3_data_out_N9 clk__L1_N0 FE_OFN1822_n4643
+ fifo_from_fft_fifo_cell2_reg_gtok_token DFFTRX2TS
Xfifo_from_fft_fifo_cell2_data_out_en_reg n8066
+ fifo_from_fft_fifo_cell2_data_out_N9 clk__L1_N0 FE_OFN1822_n4643
+ fifo_from_fft_fifo_cell1_reg_gtok_token DFFTRX2TS
Xfifo_from_fft_fifo_cell1_data_out_en_reg n8065
+ fifo_from_fft_fifo_cell1_data_out_N9 clk__L1_N0 FE_OFN720_n4643
+ fifo_from_fft_fifo_cell0_reg_gtok_token DFFTRX2TS
Xfifo_from_fir_fifo_cell15_data_out_en_reg n8094
+ fifo_from_fir_fifo_cell15_data_out_N9 clk__L1_N0 FE_OFN741_n4829
+ fifo_from_fir_fifo_cell14_reg_gtok_token DFFTRX2TS
Xfifo_from_fft_fifo_cell15_data_out_en_reg n8079
+ fifo_from_fft_fifo_cell15_data_out_N9 clk__L1_N0 FE_OFN724_n4643
+ fifo_from_fft_fifo_cell14_reg_gtok_token DFFTRX2TS
Xrouter_data_cntl_data_in_reg[31] router_data_cntl_data_in[31] clk__L1_N0 n5351
+ DFFQX1TS
Xrouter_data_cntl_data_in_reg[30] router_data_cntl_data_in[30] clk__L1_N0 n5352
+ DFFQX1TS
Xrouter_data_cntl_data_in_reg[29] router_data_cntl_data_in[29] clk__L1_N0 n5353
+ DFFQX1TS
Xrouter_data_cntl_data_in_reg[28] router_data_cntl_data_in[28] clk__L1_N0 n5354
+ DFFQX1TS
Xrouter_data_cntl_data_in_reg[27] router_data_cntl_data_in[27] clk__L1_N0 n5355
+ DFFQX1TS
Xrouter_data_cntl_data_in_reg[26] router_data_cntl_data_in[26] clk__L1_N0 n5356
+ DFFQX1TS
Xrouter_data_cntl_data_in_reg[25] router_data_cntl_data_in[25] clk__L1_N0 n5357
+ DFFQX1TS
Xrouter_data_cntl_data_in_reg[24] router_data_cntl_data_in[24] clk__L1_N0 n5358
+ DFFQX1TS
Xrouter_data_cntl_data_in_reg[23] router_data_cntl_data_in[23] clk__L1_N0 n5359
+ DFFQX1TS
Xrouter_data_cntl_data_in_reg[22] router_data_cntl_data_in[22] clk__L1_N0 n5360
+ DFFQX1TS
Xrouter_data_cntl_data_in_reg[21] router_data_cntl_data_in[21] clk__L1_N0 n5361
+ DFFQX1TS
Xrouter_data_cntl_data_in_reg[20] router_data_cntl_data_in[20] clk__L1_N0 n5362
+ DFFQX1TS
Xrouter_data_cntl_data_in_reg[19] router_data_cntl_data_in[19] clk__L1_N0 n5363
+ DFFQX1TS
Xrouter_data_cntl_data_in_reg[18] router_data_cntl_data_in[18] clk__L1_N0 n5364
+ DFFQX1TS
Xrouter_data_cntl_data_in_reg[17] router_data_cntl_data_in[17] clk__L1_N0 n5365
+ DFFQX1TS
Xrouter_data_cntl_data_in_reg[16] router_data_cntl_data_in[16] clk__L1_N0 n5366
+ DFFQX1TS
Xrouter_data_cntl_data_in_reg[15] router_data_cntl_data_in[15] clk__L1_N0 n5367
+ DFFQX1TS
Xrouter_data_cntl_data_in_reg[14] router_data_cntl_data_in[14] clk__L1_N0 n5368
+ DFFQX1TS
Xrouter_data_cntl_data_in_reg[13] router_data_cntl_data_in[13] clk__L1_N0 n5369
+ DFFQX1TS
Xrouter_data_cntl_data_in_reg[12] router_data_cntl_data_in[12] clk__L1_N0 n5370
+ DFFQX1TS
Xrouter_data_cntl_data_in_reg[11] router_data_cntl_data_in[11] clk__L1_N0 n5371
+ DFFQX1TS
Xrouter_data_cntl_data_in_reg[10] router_data_cntl_data_in[10] clk__L1_N0 n5372
+ DFFQX1TS
Xrouter_data_cntl_data_in_reg[9] router_data_cntl_data_in[9] clk__L1_N0 n5373
+ DFFQX1TS
Xrouter_data_cntl_data_in_reg[8] router_data_cntl_data_in[8] clk__L1_N0 n5374
+ DFFQX1TS
Xrouter_data_cntl_data_in_reg[7] router_data_cntl_data_in[7] clk__L1_N0 n5375
+ DFFQX1TS
Xrouter_data_cntl_data_in_reg[6] router_data_cntl_data_in[6] clk__L1_N0 n5376
+ DFFQX1TS
Xrouter_data_cntl_data_in_reg[5] router_data_cntl_data_in[5] clk__L1_N0 n5377
+ DFFQX1TS
Xrouter_data_cntl_data_in_reg[4] router_data_cntl_data_in[4] clk__L1_N0 n5378
+ DFFQX1TS
Xrouter_data_cntl_data_in_reg[3] router_data_cntl_data_in[3] clk__L1_N0 n5379
+ DFFQX1TS
Xrouter_data_cntl_data_in_reg[2] router_data_cntl_data_in[2] clk__L1_N0 n5380
+ DFFQX1TS
Xrouter_data_cntl_data_in_reg[1] router_data_cntl_data_in[1] clk__L1_N0 n5381
+ DFFQX1TS
Xrouter_data_cntl_data_in_reg[0] router_data_cntl_data_in[0] clk__L1_N0 n5382
+ DFFQX1TS
Xfifo_from_fir_fifo_cell15_data_out_do_tri[31] fir_data_in[31]
+ fifo_from_fir_fifo_cell15_sr_out[31] FE_OFN1313_n8094 TBUFX2TS
Xfifo_from_fir_fifo_cell15_data_out_do_tri[30] fir_data_in[30]
+ fifo_from_fir_fifo_cell15_sr_out[30] FE_OFN1313_n8094 TBUFX2TS
Xfifo_from_fir_fifo_cell15_data_out_do_tri[29] fir_data_in[29]
+ fifo_from_fir_fifo_cell15_sr_out[29] FE_OFN1313_n8094 TBUFX2TS
Xfifo_from_fir_fifo_cell15_data_out_do_tri[28] fir_data_in[28]
+ fifo_from_fir_fifo_cell15_sr_out[28] FE_OFN1313_n8094 TBUFX2TS
Xfifo_from_fir_fifo_cell15_data_out_do_tri[27] fir_data_in[27]
+ fifo_from_fir_fifo_cell15_sr_out[27] FE_OFN1310_n8094 TBUFX2TS
Xfifo_from_fir_fifo_cell15_data_out_do_tri[26] fir_data_in[26]
+ fifo_from_fir_fifo_cell15_sr_out[26] FE_OFN1310_n8094 TBUFX2TS
Xfifo_from_fir_fifo_cell15_data_out_do_tri[25] fir_data_in[25]
+ fifo_from_fir_fifo_cell15_sr_out[25] n8094 TBUFX2TS
Xfifo_from_fir_fifo_cell15_data_out_do_tri[24] fir_data_in[24]
+ fifo_from_fir_fifo_cell15_sr_out[24] FE_OFN1310_n8094 TBUFX2TS
Xfifo_from_fir_fifo_cell15_data_out_do_tri[23] fir_data_in[23]
+ fifo_from_fir_fifo_cell15_sr_out[23] FE_OFN1014_n2569 TBUFX2TS
Xfifo_from_fir_fifo_cell15_data_out_do_tri[22] fir_data_in[22]
+ fifo_from_fir_fifo_cell15_sr_out[22] FE_OFN1017_n2569 TBUFX2TS
Xfifo_from_fir_fifo_cell15_data_out_do_tri[21] fir_data_in[21]
+ fifo_from_fir_fifo_cell15_sr_out[21] FE_OFN1017_n2569 TBUFX2TS
Xfifo_from_fir_fifo_cell15_data_out_do_tri[20] fir_data_in[20]
+ fifo_from_fir_fifo_cell15_sr_out[20] n2569 TBUFX2TS
Xfifo_from_fir_fifo_cell15_data_out_do_tri[19] fir_data_in[19]
+ fifo_from_fir_fifo_cell15_sr_out[19] n2569 TBUFX2TS
Xfifo_from_fir_fifo_cell15_data_out_do_tri[18] fir_data_in[18]
+ fifo_from_fir_fifo_cell15_sr_out[18] FE_OFN1014_n2569 TBUFX2TS
Xfifo_from_fir_fifo_cell15_data_out_do_tri[17] fir_data_in[17]
+ fifo_from_fir_fifo_cell15_sr_out[17] n2569 TBUFX2TS
Xfifo_from_fir_fifo_cell15_data_out_do_tri[16] fir_data_in[16]
+ fifo_from_fir_fifo_cell15_sr_out[16] FE_OFN1014_n2569 TBUFX2TS
Xfifo_from_fir_fifo_cell15_data_out_do_tri[15] fir_data_in[15]
+ fifo_from_fir_fifo_cell15_sr_out[15] FE_OFN1016_n2569 TBUFX2TS
Xfifo_from_fir_fifo_cell15_data_out_do_tri[14] fir_data_in[14]
+ fifo_from_fir_fifo_cell15_sr_out[14] FE_OFN1017_n2569 TBUFX2TS
Xfifo_from_fir_fifo_cell15_data_out_do_tri[13] fir_data_in[13]
+ fifo_from_fir_fifo_cell15_sr_out[13] FE_OFN1015_n2569 TBUFX2TS
Xfifo_from_fir_fifo_cell15_data_out_do_tri[12] fir_data_in[12]
+ fifo_from_fir_fifo_cell15_sr_out[12] FE_OFN1017_n2569 TBUFX2TS
Xfifo_from_fir_fifo_cell15_data_out_do_tri[11] fir_data_in[11]
+ fifo_from_fir_fifo_cell15_sr_out[11] FE_OFN1015_n2569 TBUFX2TS
Xfifo_from_fir_fifo_cell15_data_out_do_tri[10] fir_data_in[10]
+ fifo_from_fir_fifo_cell15_sr_out[10] FE_OFN1016_n2569 TBUFX2TS
Xfifo_from_fir_fifo_cell15_data_out_do_tri[9] fir_data_in[9]
+ fifo_from_fir_fifo_cell15_sr_out[9] FE_OFN1015_n2569 TBUFX2TS
Xfifo_from_fir_fifo_cell15_data_out_do_tri[8] fir_data_in[8]
+ fifo_from_fir_fifo_cell15_sr_out[8] FE_OFN1016_n2569 TBUFX2TS
Xfifo_from_fir_fifo_cell15_data_out_do_tri[7] fir_data_in[7]
+ fifo_from_fir_fifo_cell15_sr_out[7] FE_OFN1311_n8094 TBUFX2TS
Xfifo_from_fir_fifo_cell15_data_out_do_tri[6] fir_data_in[6]
+ fifo_from_fir_fifo_cell15_sr_out[6] FE_OFN1311_n8094 TBUFX2TS
Xfifo_from_fir_fifo_cell15_data_out_do_tri[5] fir_data_in[5]
+ fifo_from_fir_fifo_cell15_sr_out[5] n8094 TBUFX2TS
Xfifo_from_fir_fifo_cell15_data_out_do_tri[4] fir_data_in[4]
+ fifo_from_fir_fifo_cell15_sr_out[4] FE_OFN1312_n8094 TBUFX2TS
Xfifo_from_fir_fifo_cell15_data_out_do_tri[3] fir_data_in[3]
+ fifo_from_fir_fifo_cell15_sr_out[3] FE_OFN1312_n8094 TBUFX2TS
Xfifo_from_fir_fifo_cell15_data_out_do_tri[2] fir_data_in[2]
+ fifo_from_fir_fifo_cell15_sr_out[2] FE_OFN1311_n8094 TBUFX2TS
Xfifo_from_fir_fifo_cell15_data_out_do_tri[1] fir_data_in[1]
+ fifo_from_fir_fifo_cell15_sr_out[1] FE_OFN1312_n8094 TBUFX2TS
Xfifo_from_fir_fifo_cell15_data_out_do_tri[0] fir_data_in[0]
+ fifo_from_fir_fifo_cell15_sr_out[0] FE_OFN1312_n8094 TBUFX2TS
Xfifo_from_fir_fifo_cell14_data_out_do_tri[31] fir_data_in[31]
+ fifo_from_fir_fifo_cell14_sr_out[31] FE_OFN1435_n8093 TBUFX2TS
Xfifo_from_fir_fifo_cell14_data_out_do_tri[30] fir_data_in[30]
+ fifo_from_fir_fifo_cell14_sr_out[30] FE_OFN1433_n8093 TBUFX2TS
Xfifo_from_fir_fifo_cell14_data_out_do_tri[29] fir_data_in[29]
+ fifo_from_fir_fifo_cell14_sr_out[29] FE_OFN1435_n8093 TBUFX2TS
Xfifo_from_fir_fifo_cell14_data_out_do_tri[28] fir_data_in[28]
+ fifo_from_fir_fifo_cell14_sr_out[28] FE_OFN1435_n8093 TBUFX2TS
Xfifo_from_fir_fifo_cell14_data_out_do_tri[27] fir_data_in[27]
+ fifo_from_fir_fifo_cell14_sr_out[27] FE_OFN1433_n8093 TBUFX2TS
Xfifo_from_fir_fifo_cell14_data_out_do_tri[26] fir_data_in[26]
+ fifo_from_fir_fifo_cell14_sr_out[26] FE_OFN1433_n8093 TBUFX2TS
Xfifo_from_fir_fifo_cell14_data_out_do_tri[25] fir_data_in[25]
+ fifo_from_fir_fifo_cell14_sr_out[25] n8093 TBUFX2TS
Xfifo_from_fir_fifo_cell14_data_out_do_tri[24] fir_data_in[24]
+ fifo_from_fir_fifo_cell14_sr_out[24] n8093 TBUFX2TS
Xfifo_from_fir_fifo_cell14_data_out_do_tri[23] fir_data_in[23]
+ fifo_from_fir_fifo_cell14_sr_out[23] FE_OFN1134_n2505 TBUFX2TS
Xfifo_from_fir_fifo_cell14_data_out_do_tri[22] fir_data_in[22]
+ fifo_from_fir_fifo_cell14_sr_out[22] FE_OFN1133_n2505 TBUFX2TS
Xfifo_from_fir_fifo_cell14_data_out_do_tri[21] fir_data_in[21]
+ fifo_from_fir_fifo_cell14_sr_out[21] FE_OFN1133_n2505 TBUFX2TS
Xfifo_from_fir_fifo_cell14_data_out_do_tri[20] fir_data_in[20]
+ fifo_from_fir_fifo_cell14_sr_out[20] n2505 TBUFX2TS
Xfifo_from_fir_fifo_cell14_data_out_do_tri[19] fir_data_in[19]
+ fifo_from_fir_fifo_cell14_sr_out[19] FE_OFN1134_n2505 TBUFX2TS
Xfifo_from_fir_fifo_cell14_data_out_do_tri[18] fir_data_in[18]
+ fifo_from_fir_fifo_cell14_sr_out[18] FE_OFN1136_n2505 TBUFX2TS
Xfifo_from_fir_fifo_cell14_data_out_do_tri[17] fir_data_in[17]
+ fifo_from_fir_fifo_cell14_sr_out[17] FE_OFN1134_n2505 TBUFX2TS
Xfifo_from_fir_fifo_cell14_data_out_do_tri[16] fir_data_in[16]
+ fifo_from_fir_fifo_cell14_sr_out[16] FE_OFN1136_n2505 TBUFX2TS
Xfifo_from_fir_fifo_cell14_data_out_do_tri[15] fir_data_in[15]
+ fifo_from_fir_fifo_cell14_sr_out[15] FE_OFN1135_n2505 TBUFX2TS
Xfifo_from_fir_fifo_cell14_data_out_do_tri[14] fir_data_in[14]
+ fifo_from_fir_fifo_cell14_sr_out[14] FE_OFN1135_n2505 TBUFX2TS
Xfifo_from_fir_fifo_cell14_data_out_do_tri[13] fir_data_in[13]
+ fifo_from_fir_fifo_cell14_sr_out[13] FE_OFN1137_n2505 TBUFX2TS
Xfifo_from_fir_fifo_cell14_data_out_do_tri[12] fir_data_in[12]
+ fifo_from_fir_fifo_cell14_sr_out[12] FE_OFN1135_n2505 TBUFX2TS
Xfifo_from_fir_fifo_cell14_data_out_do_tri[11] fir_data_in[11]
+ fifo_from_fir_fifo_cell14_sr_out[11] FE_OFN1137_n2505 TBUFX2TS
Xfifo_from_fir_fifo_cell14_data_out_do_tri[10] fir_data_in[10]
+ fifo_from_fir_fifo_cell14_sr_out[10] FE_OFN1135_n2505 TBUFX2TS
Xfifo_from_fir_fifo_cell14_data_out_do_tri[9] fir_data_in[9]
+ fifo_from_fir_fifo_cell14_sr_out[9] FE_OFN1137_n2505 TBUFX2TS
Xfifo_from_fir_fifo_cell14_data_out_do_tri[8] fir_data_in[8]
+ fifo_from_fir_fifo_cell14_sr_out[8] FE_OFN1137_n2505 TBUFX2TS
Xfifo_from_fir_fifo_cell14_data_out_do_tri[7] fir_data_in[7]
+ fifo_from_fir_fifo_cell14_sr_out[7] FE_OFN1436_n8093 TBUFX2TS
Xfifo_from_fir_fifo_cell14_data_out_do_tri[6] fir_data_in[6]
+ fifo_from_fir_fifo_cell14_sr_out[6] FE_OFN1434_n8093 TBUFX2TS
Xfifo_from_fir_fifo_cell14_data_out_do_tri[5] fir_data_in[5]
+ fifo_from_fir_fifo_cell14_sr_out[5] FE_OFN1434_n8093 TBUFX2TS
Xfifo_from_fir_fifo_cell14_data_out_do_tri[4] fir_data_in[4]
+ fifo_from_fir_fifo_cell14_sr_out[4] FE_OFN1437_n8093 TBUFX2TS
Xfifo_from_fir_fifo_cell14_data_out_do_tri[3] fir_data_in[3]
+ fifo_from_fir_fifo_cell14_sr_out[3] FE_OFN1437_n8093 TBUFX2TS
Xfifo_from_fir_fifo_cell14_data_out_do_tri[2] fir_data_in[2]
+ fifo_from_fir_fifo_cell14_sr_out[2] FE_OFN1436_n8093 TBUFX2TS
Xfifo_from_fir_fifo_cell14_data_out_do_tri[1] fir_data_in[1]
+ fifo_from_fir_fifo_cell14_sr_out[1] FE_OFN1437_n8093 TBUFX2TS
Xfifo_from_fir_fifo_cell14_data_out_do_tri[0] fir_data_in[0]
+ fifo_from_fir_fifo_cell14_sr_out[0] FE_OFN1436_n8093 TBUFX2TS
Xfifo_from_fir_fifo_cell13_data_out_do_tri[31] fir_data_in[31]
+ fifo_from_fir_fifo_cell13_sr_out[31] FE_OFN1432_n8092 TBUFX2TS
Xfifo_from_fir_fifo_cell13_data_out_do_tri[30] fir_data_in[30]
+ fifo_from_fir_fifo_cell13_sr_out[30] FE_OFN1432_n8092 TBUFX2TS
Xfifo_from_fir_fifo_cell13_data_out_do_tri[29] fir_data_in[29]
+ fifo_from_fir_fifo_cell13_sr_out[29] FE_OFN1432_n8092 TBUFX2TS
Xfifo_from_fir_fifo_cell13_data_out_do_tri[28] fir_data_in[28]
+ fifo_from_fir_fifo_cell13_sr_out[28] FE_OFN1432_n8092 TBUFX2TS
Xfifo_from_fir_fifo_cell13_data_out_do_tri[27] fir_data_in[27]
+ fifo_from_fir_fifo_cell13_sr_out[27] FE_OFN1429_n8092 TBUFX2TS
Xfifo_from_fir_fifo_cell13_data_out_do_tri[26] fir_data_in[26]
+ fifo_from_fir_fifo_cell13_sr_out[26] FE_OFN1430_n8092 TBUFX2TS
Xfifo_from_fir_fifo_cell13_data_out_do_tri[25] fir_data_in[25]
+ fifo_from_fir_fifo_cell13_sr_out[25] FE_OFN1430_n8092 TBUFX2TS
Xfifo_from_fir_fifo_cell13_data_out_do_tri[24] fir_data_in[24]
+ fifo_from_fir_fifo_cell13_sr_out[24] FE_OFN1430_n8092 TBUFX2TS
Xfifo_from_fir_fifo_cell13_data_out_do_tri[23] fir_data_in[23]
+ fifo_from_fir_fifo_cell13_sr_out[23] n2441 TBUFX2TS
Xfifo_from_fir_fifo_cell13_data_out_do_tri[22] fir_data_in[22]
+ fifo_from_fir_fifo_cell13_sr_out[22] FE_OFN1129_n2441 TBUFX2TS
Xfifo_from_fir_fifo_cell13_data_out_do_tri[21] fir_data_in[21]
+ fifo_from_fir_fifo_cell13_sr_out[21] n2441 TBUFX2TS
Xfifo_from_fir_fifo_cell13_data_out_do_tri[20] fir_data_in[20]
+ fifo_from_fir_fifo_cell13_sr_out[20] n2441 TBUFX2TS
Xfifo_from_fir_fifo_cell13_data_out_do_tri[19] fir_data_in[19]
+ fifo_from_fir_fifo_cell13_sr_out[19] FE_OFN1132_n2441 TBUFX2TS
Xfifo_from_fir_fifo_cell13_data_out_do_tri[18] fir_data_in[18]
+ fifo_from_fir_fifo_cell13_sr_out[18] FE_OFN1132_n2441 TBUFX2TS
Xfifo_from_fir_fifo_cell13_data_out_do_tri[17] fir_data_in[17]
+ fifo_from_fir_fifo_cell13_sr_out[17] FE_OFN1132_n2441 TBUFX2TS
Xfifo_from_fir_fifo_cell13_data_out_do_tri[16] fir_data_in[16]
+ fifo_from_fir_fifo_cell13_sr_out[16] FE_OFN1132_n2441 TBUFX2TS
Xfifo_from_fir_fifo_cell13_data_out_do_tri[15] fir_data_in[15]
+ fifo_from_fir_fifo_cell13_sr_out[15] FE_OFN1130_n2441 TBUFX2TS
Xfifo_from_fir_fifo_cell13_data_out_do_tri[14] fir_data_in[14]
+ fifo_from_fir_fifo_cell13_sr_out[14] FE_OFN1129_n2441 TBUFX2TS
Xfifo_from_fir_fifo_cell13_data_out_do_tri[13] fir_data_in[13]
+ fifo_from_fir_fifo_cell13_sr_out[13] FE_OFN1130_n2441 TBUFX2TS
Xfifo_from_fir_fifo_cell13_data_out_do_tri[12] fir_data_in[12]
+ fifo_from_fir_fifo_cell13_sr_out[12] FE_OFN1129_n2441 TBUFX2TS
Xfifo_from_fir_fifo_cell13_data_out_do_tri[11] fir_data_in[11]
+ fifo_from_fir_fifo_cell13_sr_out[11] FE_OFN1131_n2441 TBUFX2TS
Xfifo_from_fir_fifo_cell13_data_out_do_tri[10] fir_data_in[10]
+ fifo_from_fir_fifo_cell13_sr_out[10] FE_OFN1131_n2441 TBUFX2TS
Xfifo_from_fir_fifo_cell13_data_out_do_tri[9] fir_data_in[9]
+ fifo_from_fir_fifo_cell13_sr_out[9] FE_OFN1131_n2441 TBUFX2TS
Xfifo_from_fir_fifo_cell13_data_out_do_tri[8] fir_data_in[8]
+ fifo_from_fir_fifo_cell13_sr_out[8] FE_OFN1131_n2441 TBUFX2TS
Xfifo_from_fir_fifo_cell13_data_out_do_tri[7] fir_data_in[7]
+ fifo_from_fir_fifo_cell13_sr_out[7] n8092 TBUFX2TS
Xfifo_from_fir_fifo_cell13_data_out_do_tri[6] fir_data_in[6]
+ fifo_from_fir_fifo_cell13_sr_out[6] FE_OFN1429_n8092 TBUFX2TS
Xfifo_from_fir_fifo_cell13_data_out_do_tri[5] fir_data_in[5]
+ fifo_from_fir_fifo_cell13_sr_out[5] FE_OFN1429_n8092 TBUFX2TS
Xfifo_from_fir_fifo_cell13_data_out_do_tri[4] fir_data_in[4]
+ fifo_from_fir_fifo_cell13_sr_out[4] n8092 TBUFX2TS
Xfifo_from_fir_fifo_cell13_data_out_do_tri[3] fir_data_in[3]
+ fifo_from_fir_fifo_cell13_sr_out[3] FE_OFN1431_n8092 TBUFX2TS
Xfifo_from_fir_fifo_cell13_data_out_do_tri[2] fir_data_in[2]
+ fifo_from_fir_fifo_cell13_sr_out[2] FE_OFN1431_n8092 TBUFX2TS
Xfifo_from_fir_fifo_cell13_data_out_do_tri[1] fir_data_in[1]
+ fifo_from_fir_fifo_cell13_sr_out[1] FE_OFN1431_n8092 TBUFX2TS
Xfifo_from_fir_fifo_cell13_data_out_do_tri[0] fir_data_in[0]
+ fifo_from_fir_fifo_cell13_sr_out[0] FE_OFN1431_n8092 TBUFX2TS
Xfifo_from_fir_fifo_cell12_data_out_do_tri[31] fir_data_in[31]
+ fifo_from_fir_fifo_cell12_sr_out[31] FE_OFN1428_n8091 TBUFX2TS
Xfifo_from_fir_fifo_cell12_data_out_do_tri[30] fir_data_in[30]
+ fifo_from_fir_fifo_cell12_sr_out[30] FE_OFN1428_n8091 TBUFX2TS
Xfifo_from_fir_fifo_cell12_data_out_do_tri[29] fir_data_in[29]
+ fifo_from_fir_fifo_cell12_sr_out[29] FE_OFN1428_n8091 TBUFX2TS
Xfifo_from_fir_fifo_cell12_data_out_do_tri[28] fir_data_in[28]
+ fifo_from_fir_fifo_cell12_sr_out[28] FE_OFN1428_n8091 TBUFX2TS
Xfifo_from_fir_fifo_cell12_data_out_do_tri[27] fir_data_in[27]
+ fifo_from_fir_fifo_cell12_sr_out[27] FE_OFN1427_n8091 TBUFX2TS
Xfifo_from_fir_fifo_cell12_data_out_do_tri[26] fir_data_in[26]
+ fifo_from_fir_fifo_cell12_sr_out[26] FE_OFN1427_n8091 TBUFX2TS
Xfifo_from_fir_fifo_cell12_data_out_do_tri[25] fir_data_in[25]
+ fifo_from_fir_fifo_cell12_sr_out[25] FE_OFN1427_n8091 TBUFX2TS
Xfifo_from_fir_fifo_cell12_data_out_do_tri[24] fir_data_in[24]
+ fifo_from_fir_fifo_cell12_sr_out[24] FE_OFN1427_n8091 TBUFX2TS
Xfifo_from_fir_fifo_cell12_data_out_do_tri[23] fir_data_in[23]
+ fifo_from_fir_fifo_cell12_sr_out[23] FE_OFN1124_n2377 TBUFX2TS
Xfifo_from_fir_fifo_cell12_data_out_do_tri[22] fir_data_in[22]
+ fifo_from_fir_fifo_cell12_sr_out[22] FE_OFN1128_n2377 TBUFX2TS
Xfifo_from_fir_fifo_cell12_data_out_do_tri[21] fir_data_in[21]
+ fifo_from_fir_fifo_cell12_sr_out[21] FE_OFN1128_n2377 TBUFX2TS
Xfifo_from_fir_fifo_cell12_data_out_do_tri[20] fir_data_in[20]
+ fifo_from_fir_fifo_cell12_sr_out[20] n2377 TBUFX2TS
Xfifo_from_fir_fifo_cell12_data_out_do_tri[19] fir_data_in[19]
+ fifo_from_fir_fifo_cell12_sr_out[19] n2377 TBUFX2TS
Xfifo_from_fir_fifo_cell12_data_out_do_tri[18] fir_data_in[18]
+ fifo_from_fir_fifo_cell12_sr_out[18] FE_OFN1125_n2377 TBUFX2TS
Xfifo_from_fir_fifo_cell12_data_out_do_tri[17] fir_data_in[17]
+ fifo_from_fir_fifo_cell12_sr_out[17] FE_OFN1124_n2377 TBUFX2TS
Xfifo_from_fir_fifo_cell12_data_out_do_tri[16] fir_data_in[16]
+ fifo_from_fir_fifo_cell12_sr_out[16] FE_OFN1124_n2377 TBUFX2TS
Xfifo_from_fir_fifo_cell12_data_out_do_tri[15] fir_data_in[15]
+ fifo_from_fir_fifo_cell12_sr_out[15] FE_OFN1126_n2377 TBUFX2TS
Xfifo_from_fir_fifo_cell12_data_out_do_tri[14] fir_data_in[14]
+ fifo_from_fir_fifo_cell12_sr_out[14] FE_OFN1128_n2377 TBUFX2TS
Xfifo_from_fir_fifo_cell12_data_out_do_tri[13] fir_data_in[13]
+ fifo_from_fir_fifo_cell12_sr_out[13] FE_OFN1125_n2377 TBUFX2TS
Xfifo_from_fir_fifo_cell12_data_out_do_tri[12] fir_data_in[12]
+ fifo_from_fir_fifo_cell12_sr_out[12] FE_OFN1128_n2377 TBUFX2TS
Xfifo_from_fir_fifo_cell12_data_out_do_tri[11] fir_data_in[11]
+ fifo_from_fir_fifo_cell12_sr_out[11] FE_OFN1127_n2377 TBUFX2TS
Xfifo_from_fir_fifo_cell12_data_out_do_tri[10] fir_data_in[10]
+ fifo_from_fir_fifo_cell12_sr_out[10] FE_OFN1126_n2377 TBUFX2TS
Xfifo_from_fir_fifo_cell12_data_out_do_tri[9] fir_data_in[9]
+ fifo_from_fir_fifo_cell12_sr_out[9] FE_OFN1127_n2377 TBUFX2TS
Xfifo_from_fir_fifo_cell12_data_out_do_tri[8] fir_data_in[8]
+ fifo_from_fir_fifo_cell12_sr_out[8] FE_OFN1127_n2377 TBUFX2TS
Xfifo_from_fir_fifo_cell12_data_out_do_tri[7] fir_data_in[7]
+ fifo_from_fir_fifo_cell12_sr_out[7] n8091 TBUFX2TS
Xfifo_from_fir_fifo_cell12_data_out_do_tri[6] fir_data_in[6]
+ fifo_from_fir_fifo_cell12_sr_out[6] FE_OFN1425_n8091 TBUFX2TS
Xfifo_from_fir_fifo_cell12_data_out_do_tri[5] fir_data_in[5]
+ fifo_from_fir_fifo_cell12_sr_out[5] FE_OFN1425_n8091 TBUFX2TS
Xfifo_from_fir_fifo_cell12_data_out_do_tri[4] fir_data_in[4]
+ fifo_from_fir_fifo_cell12_sr_out[4] FE_OFN1426_n8091 TBUFX2TS
Xfifo_from_fir_fifo_cell12_data_out_do_tri[3] fir_data_in[3]
+ fifo_from_fir_fifo_cell12_sr_out[3] FE_OFN1426_n8091 TBUFX2TS
Xfifo_from_fir_fifo_cell12_data_out_do_tri[2] fir_data_in[2]
+ fifo_from_fir_fifo_cell12_sr_out[2] n8091 TBUFX2TS
Xfifo_from_fir_fifo_cell12_data_out_do_tri[1] fir_data_in[1]
+ fifo_from_fir_fifo_cell12_sr_out[1] FE_OFN1426_n8091 TBUFX2TS
Xfifo_from_fir_fifo_cell12_data_out_do_tri[0] fir_data_in[0]
+ fifo_from_fir_fifo_cell12_sr_out[0] FE_OFN1426_n8091 TBUFX2TS
Xfifo_from_fir_fifo_cell11_data_out_do_tri[31] fir_data_in[31]
+ fifo_from_fir_fifo_cell11_sr_out[31] FE_OFN1424_n8090 TBUFX2TS
Xfifo_from_fir_fifo_cell11_data_out_do_tri[30] fir_data_in[30]
+ fifo_from_fir_fifo_cell11_sr_out[30] FE_OFN1424_n8090 TBUFX2TS
Xfifo_from_fir_fifo_cell11_data_out_do_tri[29] fir_data_in[29]
+ fifo_from_fir_fifo_cell11_sr_out[29] FE_OFN1424_n8090 TBUFX2TS
Xfifo_from_fir_fifo_cell11_data_out_do_tri[28] fir_data_in[28]
+ fifo_from_fir_fifo_cell11_sr_out[28] FE_OFN1424_n8090 TBUFX2TS
Xfifo_from_fir_fifo_cell11_data_out_do_tri[27] fir_data_in[27]
+ fifo_from_fir_fifo_cell11_sr_out[27] FE_OFN1422_n8090 TBUFX2TS
Xfifo_from_fir_fifo_cell11_data_out_do_tri[26] fir_data_in[26]
+ fifo_from_fir_fifo_cell11_sr_out[26] FE_OFN1423_n8090 TBUFX2TS
Xfifo_from_fir_fifo_cell11_data_out_do_tri[25] fir_data_in[25]
+ fifo_from_fir_fifo_cell11_sr_out[25] FE_OFN1423_n8090 TBUFX2TS
Xfifo_from_fir_fifo_cell11_data_out_do_tri[24] fir_data_in[24]
+ fifo_from_fir_fifo_cell11_sr_out[24] FE_OFN1423_n8090 TBUFX2TS
Xfifo_from_fir_fifo_cell11_data_out_do_tri[23] fir_data_in[23]
+ fifo_from_fir_fifo_cell11_sr_out[23] n2313 TBUFX2TS
Xfifo_from_fir_fifo_cell11_data_out_do_tri[22] fir_data_in[22]
+ fifo_from_fir_fifo_cell11_sr_out[22] FE_OFN1123_n2313 TBUFX2TS
Xfifo_from_fir_fifo_cell11_data_out_do_tri[21] fir_data_in[21]
+ fifo_from_fir_fifo_cell11_sr_out[21] n2313 TBUFX2TS
Xfifo_from_fir_fifo_cell11_data_out_do_tri[20] fir_data_in[20]
+ fifo_from_fir_fifo_cell11_sr_out[20] n2313 TBUFX2TS
Xfifo_from_fir_fifo_cell11_data_out_do_tri[19] fir_data_in[19]
+ fifo_from_fir_fifo_cell11_sr_out[19] FE_OFN1120_n2313 TBUFX2TS
Xfifo_from_fir_fifo_cell11_data_out_do_tri[18] fir_data_in[18]
+ fifo_from_fir_fifo_cell11_sr_out[18] FE_OFN1121_n2313 TBUFX2TS
Xfifo_from_fir_fifo_cell11_data_out_do_tri[17] fir_data_in[17]
+ fifo_from_fir_fifo_cell11_sr_out[17] FE_OFN1120_n2313 TBUFX2TS
Xfifo_from_fir_fifo_cell11_data_out_do_tri[16] fir_data_in[16]
+ fifo_from_fir_fifo_cell11_sr_out[16] FE_OFN1120_n2313 TBUFX2TS
Xfifo_from_fir_fifo_cell11_data_out_do_tri[15] fir_data_in[15]
+ fifo_from_fir_fifo_cell11_sr_out[15] FE_OFN1123_n2313 TBUFX2TS
Xfifo_from_fir_fifo_cell11_data_out_do_tri[14] fir_data_in[14]
+ fifo_from_fir_fifo_cell11_sr_out[14] FE_OFN1123_n2313 TBUFX2TS
Xfifo_from_fir_fifo_cell11_data_out_do_tri[13] fir_data_in[13]
+ fifo_from_fir_fifo_cell11_sr_out[13] FE_OFN1121_n2313 TBUFX2TS
Xfifo_from_fir_fifo_cell11_data_out_do_tri[12] fir_data_in[12]
+ fifo_from_fir_fifo_cell11_sr_out[12] FE_OFN1123_n2313 TBUFX2TS
Xfifo_from_fir_fifo_cell11_data_out_do_tri[11] fir_data_in[11]
+ fifo_from_fir_fifo_cell11_sr_out[11] FE_OFN1121_n2313 TBUFX2TS
Xfifo_from_fir_fifo_cell11_data_out_do_tri[10] fir_data_in[10]
+ fifo_from_fir_fifo_cell11_sr_out[10] FE_OFN1122_n2313 TBUFX2TS
Xfifo_from_fir_fifo_cell11_data_out_do_tri[9] fir_data_in[9]
+ fifo_from_fir_fifo_cell11_sr_out[9] FE_OFN1122_n2313 TBUFX2TS
Xfifo_from_fir_fifo_cell11_data_out_do_tri[8] fir_data_in[8]
+ fifo_from_fir_fifo_cell11_sr_out[8] FE_OFN1122_n2313 TBUFX2TS
Xfifo_from_fir_fifo_cell11_data_out_do_tri[7] fir_data_in[7]
+ fifo_from_fir_fifo_cell11_sr_out[7] FE_OFN1421_n8090 TBUFX2TS
Xfifo_from_fir_fifo_cell11_data_out_do_tri[6] fir_data_in[6]
+ fifo_from_fir_fifo_cell11_sr_out[6] FE_OFN1420_n8090 TBUFX2TS
Xfifo_from_fir_fifo_cell11_data_out_do_tri[5] fir_data_in[5]
+ fifo_from_fir_fifo_cell11_sr_out[5] FE_OFN1422_n8090 TBUFX2TS
Xfifo_from_fir_fifo_cell11_data_out_do_tri[4] fir_data_in[4]
+ fifo_from_fir_fifo_cell11_sr_out[4] FE_OFN1420_n8090 TBUFX2TS
Xfifo_from_fir_fifo_cell11_data_out_do_tri[3] fir_data_in[3]
+ fifo_from_fir_fifo_cell11_sr_out[3] FE_OFN1421_n8090 TBUFX2TS
Xfifo_from_fir_fifo_cell11_data_out_do_tri[2] fir_data_in[2]
+ fifo_from_fir_fifo_cell11_sr_out[2] FE_OFN1421_n8090 TBUFX2TS
Xfifo_from_fir_fifo_cell11_data_out_do_tri[1] fir_data_in[1]
+ fifo_from_fir_fifo_cell11_sr_out[1] n8090 TBUFX2TS
Xfifo_from_fir_fifo_cell11_data_out_do_tri[0] fir_data_in[0]
+ fifo_from_fir_fifo_cell11_sr_out[0] FE_OFN1421_n8090 TBUFX2TS
Xfifo_from_fir_fifo_cell10_data_out_do_tri[31] fir_data_in[31]
+ fifo_from_fir_fifo_cell10_sr_out[31] FE_OFN1419_n8089 TBUFX2TS
Xfifo_from_fir_fifo_cell10_data_out_do_tri[30] fir_data_in[30]
+ fifo_from_fir_fifo_cell10_sr_out[30] FE_OFN1417_n8089 TBUFX2TS
Xfifo_from_fir_fifo_cell10_data_out_do_tri[29] fir_data_in[29]
+ fifo_from_fir_fifo_cell10_sr_out[29] FE_OFN1419_n8089 TBUFX2TS
Xfifo_from_fir_fifo_cell10_data_out_do_tri[28] fir_data_in[28]
+ fifo_from_fir_fifo_cell10_sr_out[28] FE_OFN1419_n8089 TBUFX2TS
Xfifo_from_fir_fifo_cell10_data_out_do_tri[27] fir_data_in[27]
+ fifo_from_fir_fifo_cell10_sr_out[27] FE_OFN1419_n8089 TBUFX2TS
Xfifo_from_fir_fifo_cell10_data_out_do_tri[26] fir_data_in[26]
+ fifo_from_fir_fifo_cell10_sr_out[26] FE_OFN1418_n8089 TBUFX2TS
Xfifo_from_fir_fifo_cell10_data_out_do_tri[25] fir_data_in[25]
+ fifo_from_fir_fifo_cell10_sr_out[25] FE_OFN1418_n8089 TBUFX2TS
Xfifo_from_fir_fifo_cell10_data_out_do_tri[24] fir_data_in[24]
+ fifo_from_fir_fifo_cell10_sr_out[24] FE_OFN1418_n8089 TBUFX2TS
Xfifo_from_fir_fifo_cell10_data_out_do_tri[23] fir_data_in[23]
+ fifo_from_fir_fifo_cell10_sr_out[23] FE_OFN1115_n2249 TBUFX2TS
Xfifo_from_fir_fifo_cell10_data_out_do_tri[22] fir_data_in[22]
+ fifo_from_fir_fifo_cell10_sr_out[22] FE_OFN1119_n2249 TBUFX2TS
Xfifo_from_fir_fifo_cell10_data_out_do_tri[21] fir_data_in[21]
+ fifo_from_fir_fifo_cell10_sr_out[21] n2249 TBUFX2TS
Xfifo_from_fir_fifo_cell10_data_out_do_tri[20] fir_data_in[20]
+ fifo_from_fir_fifo_cell10_sr_out[20] n2249 TBUFX2TS
Xfifo_from_fir_fifo_cell10_data_out_do_tri[19] fir_data_in[19]
+ fifo_from_fir_fifo_cell10_sr_out[19] FE_OFN1115_n2249 TBUFX2TS
Xfifo_from_fir_fifo_cell10_data_out_do_tri[18] fir_data_in[18]
+ fifo_from_fir_fifo_cell10_sr_out[18] FE_OFN1116_n2249 TBUFX2TS
Xfifo_from_fir_fifo_cell10_data_out_do_tri[17] fir_data_in[17]
+ fifo_from_fir_fifo_cell10_sr_out[17] FE_OFN1115_n2249 TBUFX2TS
Xfifo_from_fir_fifo_cell10_data_out_do_tri[16] fir_data_in[16]
+ fifo_from_fir_fifo_cell10_sr_out[16] FE_OFN1116_n2249 TBUFX2TS
Xfifo_from_fir_fifo_cell10_data_out_do_tri[15] fir_data_in[15]
+ fifo_from_fir_fifo_cell10_sr_out[15] FE_OFN1119_n2249 TBUFX2TS
Xfifo_from_fir_fifo_cell10_data_out_do_tri[14] fir_data_in[14]
+ fifo_from_fir_fifo_cell10_sr_out[14] FE_OFN1119_n2249 TBUFX2TS
Xfifo_from_fir_fifo_cell10_data_out_do_tri[13] fir_data_in[13]
+ fifo_from_fir_fifo_cell10_sr_out[13] FE_OFN1116_n2249 TBUFX2TS
Xfifo_from_fir_fifo_cell10_data_out_do_tri[12] fir_data_in[12]
+ fifo_from_fir_fifo_cell10_sr_out[12] FE_OFN1119_n2249 TBUFX2TS
Xfifo_from_fir_fifo_cell10_data_out_do_tri[11] fir_data_in[11]
+ fifo_from_fir_fifo_cell10_sr_out[11] FE_OFN1118_n2249 TBUFX2TS
Xfifo_from_fir_fifo_cell10_data_out_do_tri[10] fir_data_in[10]
+ fifo_from_fir_fifo_cell10_sr_out[10] FE_OFN1117_n2249 TBUFX2TS
Xfifo_from_fir_fifo_cell10_data_out_do_tri[9] fir_data_in[9]
+ fifo_from_fir_fifo_cell10_sr_out[9] FE_OFN1118_n2249 TBUFX2TS
Xfifo_from_fir_fifo_cell10_data_out_do_tri[8] fir_data_in[8]
+ fifo_from_fir_fifo_cell10_sr_out[8] FE_OFN1118_n2249 TBUFX2TS
Xfifo_from_fir_fifo_cell10_data_out_do_tri[7] fir_data_in[7]
+ fifo_from_fir_fifo_cell10_sr_out[7] FE_OFN1416_n8089 TBUFX2TS
Xfifo_from_fir_fifo_cell10_data_out_do_tri[6] fir_data_in[6]
+ fifo_from_fir_fifo_cell10_sr_out[6] FE_OFN1417_n8089 TBUFX2TS
Xfifo_from_fir_fifo_cell10_data_out_do_tri[5] fir_data_in[5]
+ fifo_from_fir_fifo_cell10_sr_out[5] FE_OFN1418_n8089 TBUFX2TS
Xfifo_from_fir_fifo_cell10_data_out_do_tri[4] fir_data_in[4]
+ fifo_from_fir_fifo_cell10_sr_out[4] n8089 TBUFX2TS
Xfifo_from_fir_fifo_cell10_data_out_do_tri[3] fir_data_in[3]
+ fifo_from_fir_fifo_cell10_sr_out[3] n8089 TBUFX2TS
Xfifo_from_fir_fifo_cell10_data_out_do_tri[2] fir_data_in[2]
+ fifo_from_fir_fifo_cell10_sr_out[2] FE_OFN1416_n8089 TBUFX2TS
Xfifo_from_fir_fifo_cell10_data_out_do_tri[1] fir_data_in[1]
+ fifo_from_fir_fifo_cell10_sr_out[1] n8089 TBUFX2TS
Xfifo_from_fir_fifo_cell10_data_out_do_tri[0] fir_data_in[0]
+ fifo_from_fir_fifo_cell10_sr_out[0] FE_OFN1416_n8089 TBUFX2TS
Xfifo_from_fir_fifo_cell9_data_out_do_tri[31] fir_data_in[31]
+ fifo_from_fir_fifo_cell9_sr_out[31] FE_OFN1415_n8088 TBUFX2TS
Xfifo_from_fir_fifo_cell9_data_out_do_tri[30] fir_data_in[30]
+ fifo_from_fir_fifo_cell9_sr_out[30] FE_OFN1415_n8088 TBUFX2TS
Xfifo_from_fir_fifo_cell9_data_out_do_tri[29] fir_data_in[29]
+ fifo_from_fir_fifo_cell9_sr_out[29] FE_OFN1415_n8088 TBUFX2TS
Xfifo_from_fir_fifo_cell9_data_out_do_tri[28] fir_data_in[28]
+ fifo_from_fir_fifo_cell9_sr_out[28] FE_OFN1415_n8088 TBUFX2TS
Xfifo_from_fir_fifo_cell9_data_out_do_tri[27] fir_data_in[27]
+ fifo_from_fir_fifo_cell9_sr_out[27] FE_OFN1414_n8088 TBUFX2TS
Xfifo_from_fir_fifo_cell9_data_out_do_tri[26] fir_data_in[26]
+ fifo_from_fir_fifo_cell9_sr_out[26] FE_OFN1413_n8088 TBUFX2TS
Xfifo_from_fir_fifo_cell9_data_out_do_tri[25] fir_data_in[25]
+ fifo_from_fir_fifo_cell9_sr_out[25] FE_OFN1414_n8088 TBUFX2TS
Xfifo_from_fir_fifo_cell9_data_out_do_tri[24] fir_data_in[24]
+ fifo_from_fir_fifo_cell9_sr_out[24] FE_OFN1414_n8088 TBUFX2TS
Xfifo_from_fir_fifo_cell9_data_out_do_tri[23] fir_data_in[23]
+ fifo_from_fir_fifo_cell9_sr_out[23] n2185 TBUFX2TS
Xfifo_from_fir_fifo_cell9_data_out_do_tri[22] fir_data_in[22]
+ fifo_from_fir_fifo_cell9_sr_out[22] FE_OFN1111_n2185 TBUFX2TS
Xfifo_from_fir_fifo_cell9_data_out_do_tri[21] fir_data_in[21]
+ fifo_from_fir_fifo_cell9_sr_out[21] FE_OFN1111_n2185 TBUFX2TS
Xfifo_from_fir_fifo_cell9_data_out_do_tri[20] fir_data_in[20]
+ fifo_from_fir_fifo_cell9_sr_out[20] FE_OFN1111_n2185 TBUFX2TS
Xfifo_from_fir_fifo_cell9_data_out_do_tri[19] fir_data_in[19]
+ fifo_from_fir_fifo_cell9_sr_out[19] n2185 TBUFX2TS
Xfifo_from_fir_fifo_cell9_data_out_do_tri[18] fir_data_in[18]
+ fifo_from_fir_fifo_cell9_sr_out[18] FE_OFN1112_n2185 TBUFX2TS
Xfifo_from_fir_fifo_cell9_data_out_do_tri[17] fir_data_in[17]
+ fifo_from_fir_fifo_cell9_sr_out[17] FE_OFN1112_n2185 TBUFX2TS
Xfifo_from_fir_fifo_cell9_data_out_do_tri[16] fir_data_in[16]
+ fifo_from_fir_fifo_cell9_sr_out[16] FE_OFN1112_n2185 TBUFX2TS
Xfifo_from_fir_fifo_cell9_data_out_do_tri[15] fir_data_in[15]
+ fifo_from_fir_fifo_cell9_sr_out[15] FE_OFN1113_n2185 TBUFX2TS
Xfifo_from_fir_fifo_cell9_data_out_do_tri[14] fir_data_in[14]
+ fifo_from_fir_fifo_cell9_sr_out[14] FE_OFN1113_n2185 TBUFX2TS
Xfifo_from_fir_fifo_cell9_data_out_do_tri[13] fir_data_in[13]
+ fifo_from_fir_fifo_cell9_sr_out[13] FE_OFN1114_n2185 TBUFX2TS
Xfifo_from_fir_fifo_cell9_data_out_do_tri[12] fir_data_in[12]
+ fifo_from_fir_fifo_cell9_sr_out[12] FE_OFN1113_n2185 TBUFX2TS
Xfifo_from_fir_fifo_cell9_data_out_do_tri[11] fir_data_in[11]
+ fifo_from_fir_fifo_cell9_sr_out[11] FE_OFN1114_n2185 TBUFX2TS
Xfifo_from_fir_fifo_cell9_data_out_do_tri[10] fir_data_in[10]
+ fifo_from_fir_fifo_cell9_sr_out[10] FE_OFN1113_n2185 TBUFX2TS
Xfifo_from_fir_fifo_cell9_data_out_do_tri[9] fir_data_in[9]
+ fifo_from_fir_fifo_cell9_sr_out[9] FE_OFN1114_n2185 TBUFX2TS
Xfifo_from_fir_fifo_cell9_data_out_do_tri[8] fir_data_in[8]
+ fifo_from_fir_fifo_cell9_sr_out[8] FE_OFN1114_n2185 TBUFX2TS
Xfifo_from_fir_fifo_cell9_data_out_do_tri[7] fir_data_in[7]
+ fifo_from_fir_fifo_cell9_sr_out[7] FE_OFN1412_n8088 TBUFX2TS
Xfifo_from_fir_fifo_cell9_data_out_do_tri[6] fir_data_in[6]
+ fifo_from_fir_fifo_cell9_sr_out[6] FE_OFN1413_n8088 TBUFX2TS
Xfifo_from_fir_fifo_cell9_data_out_do_tri[5] fir_data_in[5]
+ fifo_from_fir_fifo_cell9_sr_out[5] FE_OFN1413_n8088 TBUFX2TS
Xfifo_from_fir_fifo_cell9_data_out_do_tri[4] fir_data_in[4]
+ fifo_from_fir_fifo_cell9_sr_out[4] FE_OFN1412_n8088 TBUFX2TS
Xfifo_from_fir_fifo_cell9_data_out_do_tri[3] fir_data_in[3]
+ fifo_from_fir_fifo_cell9_sr_out[3] n8088 TBUFX2TS
Xfifo_from_fir_fifo_cell9_data_out_do_tri[2] fir_data_in[2]
+ fifo_from_fir_fifo_cell9_sr_out[2] FE_OFN1412_n8088 TBUFX2TS
Xfifo_from_fir_fifo_cell9_data_out_do_tri[1] fir_data_in[1]
+ fifo_from_fir_fifo_cell9_sr_out[1] n8088 TBUFX2TS
Xfifo_from_fir_fifo_cell9_data_out_do_tri[0] fir_data_in[0]
+ fifo_from_fir_fifo_cell9_sr_out[0] n8088 TBUFX2TS
Xfifo_from_fir_fifo_cell8_data_out_do_tri[31] fir_data_in[31]
+ fifo_from_fir_fifo_cell8_sr_out[31] FE_OFN1411_n8087 TBUFX2TS
Xfifo_from_fir_fifo_cell8_data_out_do_tri[30] fir_data_in[30]
+ fifo_from_fir_fifo_cell8_sr_out[30] FE_OFN1411_n8087 TBUFX2TS
Xfifo_from_fir_fifo_cell8_data_out_do_tri[29] fir_data_in[29]
+ fifo_from_fir_fifo_cell8_sr_out[29] FE_OFN1411_n8087 TBUFX2TS
Xfifo_from_fir_fifo_cell8_data_out_do_tri[28] fir_data_in[28]
+ fifo_from_fir_fifo_cell8_sr_out[28] FE_OFN1411_n8087 TBUFX2TS
Xfifo_from_fir_fifo_cell8_data_out_do_tri[27] fir_data_in[27]
+ fifo_from_fir_fifo_cell8_sr_out[27] FE_OFN1409_n8087 TBUFX2TS
Xfifo_from_fir_fifo_cell8_data_out_do_tri[26] fir_data_in[26]
+ fifo_from_fir_fifo_cell8_sr_out[26] FE_OFN1409_n8087 TBUFX2TS
Xfifo_from_fir_fifo_cell8_data_out_do_tri[25] fir_data_in[25]
+ fifo_from_fir_fifo_cell8_sr_out[25] FE_OFN1410_n8087 TBUFX2TS
Xfifo_from_fir_fifo_cell8_data_out_do_tri[24] fir_data_in[24]
+ fifo_from_fir_fifo_cell8_sr_out[24] FE_OFN1410_n8087 TBUFX2TS
Xfifo_from_fir_fifo_cell8_data_out_do_tri[23] fir_data_in[23]
+ fifo_from_fir_fifo_cell8_sr_out[23] FE_OFN1108_n2121 TBUFX2TS
Xfifo_from_fir_fifo_cell8_data_out_do_tri[22] fir_data_in[22]
+ fifo_from_fir_fifo_cell8_sr_out[22] FE_OFN1109_n2121 TBUFX2TS
Xfifo_from_fir_fifo_cell8_data_out_do_tri[21] fir_data_in[21]
+ fifo_from_fir_fifo_cell8_sr_out[21] FE_OFN1106_n2121 TBUFX2TS
Xfifo_from_fir_fifo_cell8_data_out_do_tri[20] fir_data_in[20]
+ fifo_from_fir_fifo_cell8_sr_out[20] n2121 TBUFX2TS
Xfifo_from_fir_fifo_cell8_data_out_do_tri[19] fir_data_in[19]
+ fifo_from_fir_fifo_cell8_sr_out[19] FE_OFN1108_n2121 TBUFX2TS
Xfifo_from_fir_fifo_cell8_data_out_do_tri[18] fir_data_in[18]
+ fifo_from_fir_fifo_cell8_sr_out[18] FE_OFN1107_n2121 TBUFX2TS
Xfifo_from_fir_fifo_cell8_data_out_do_tri[17] fir_data_in[17]
+ fifo_from_fir_fifo_cell8_sr_out[17] FE_OFN1108_n2121 TBUFX2TS
Xfifo_from_fir_fifo_cell8_data_out_do_tri[16] fir_data_in[16]
+ fifo_from_fir_fifo_cell8_sr_out[16] FE_OFN1107_n2121 TBUFX2TS
Xfifo_from_fir_fifo_cell8_data_out_do_tri[15] fir_data_in[15]
+ fifo_from_fir_fifo_cell8_sr_out[15] FE_OFN1106_n2121 TBUFX2TS
Xfifo_from_fir_fifo_cell8_data_out_do_tri[14] fir_data_in[14]
+ fifo_from_fir_fifo_cell8_sr_out[14] FE_OFN1109_n2121 TBUFX2TS
Xfifo_from_fir_fifo_cell8_data_out_do_tri[13] fir_data_in[13]
+ fifo_from_fir_fifo_cell8_sr_out[13] FE_OFN1110_n2121 TBUFX2TS
Xfifo_from_fir_fifo_cell8_data_out_do_tri[12] fir_data_in[12]
+ fifo_from_fir_fifo_cell8_sr_out[12] FE_OFN1109_n2121 TBUFX2TS
Xfifo_from_fir_fifo_cell8_data_out_do_tri[11] fir_data_in[11]
+ fifo_from_fir_fifo_cell8_sr_out[11] FE_OFN1110_n2121 TBUFX2TS
Xfifo_from_fir_fifo_cell8_data_out_do_tri[10] fir_data_in[10]
+ fifo_from_fir_fifo_cell8_sr_out[10] FE_OFN1109_n2121 TBUFX2TS
Xfifo_from_fir_fifo_cell8_data_out_do_tri[9] fir_data_in[9]
+ fifo_from_fir_fifo_cell8_sr_out[9] FE_OFN1110_n2121 TBUFX2TS
Xfifo_from_fir_fifo_cell8_data_out_do_tri[8] fir_data_in[8]
+ fifo_from_fir_fifo_cell8_sr_out[8] FE_OFN1110_n2121 TBUFX2TS
Xfifo_from_fir_fifo_cell8_data_out_do_tri[7] fir_data_in[7]
+ fifo_from_fir_fifo_cell8_sr_out[7] FE_OFN1407_n8087 TBUFX2TS
Xfifo_from_fir_fifo_cell8_data_out_do_tri[6] fir_data_in[6]
+ fifo_from_fir_fifo_cell8_sr_out[6] FE_OFN1408_n8087 TBUFX2TS
Xfifo_from_fir_fifo_cell8_data_out_do_tri[5] fir_data_in[5]
+ fifo_from_fir_fifo_cell8_sr_out[5] FE_OFN1408_n8087 TBUFX2TS
Xfifo_from_fir_fifo_cell8_data_out_do_tri[4] fir_data_in[4]
+ fifo_from_fir_fifo_cell8_sr_out[4] FE_OFN1408_n8087 TBUFX2TS
Xfifo_from_fir_fifo_cell8_data_out_do_tri[3] fir_data_in[3]
+ fifo_from_fir_fifo_cell8_sr_out[3] n8087 TBUFX2TS
Xfifo_from_fir_fifo_cell8_data_out_do_tri[2] fir_data_in[2]
+ fifo_from_fir_fifo_cell8_sr_out[2] FE_OFN1407_n8087 TBUFX2TS
Xfifo_from_fir_fifo_cell8_data_out_do_tri[1] fir_data_in[1]
+ fifo_from_fir_fifo_cell8_sr_out[1] n8087 TBUFX2TS
Xfifo_from_fir_fifo_cell8_data_out_do_tri[0] fir_data_in[0]
+ fifo_from_fir_fifo_cell8_sr_out[0] FE_OFN1407_n8087 TBUFX2TS
Xfifo_from_fir_fifo_cell7_data_out_do_tri[31] fir_data_in[31]
+ fifo_from_fir_fifo_cell7_sr_out[31] FE_OFN1406_n8086 TBUFX2TS
Xfifo_from_fir_fifo_cell7_data_out_do_tri[30] fir_data_in[30]
+ fifo_from_fir_fifo_cell7_sr_out[30] FE_OFN1406_n8086 TBUFX2TS
Xfifo_from_fir_fifo_cell7_data_out_do_tri[29] fir_data_in[29]
+ fifo_from_fir_fifo_cell7_sr_out[29] FE_OFN1406_n8086 TBUFX2TS
Xfifo_from_fir_fifo_cell7_data_out_do_tri[28] fir_data_in[28]
+ fifo_from_fir_fifo_cell7_sr_out[28] FE_OFN1406_n8086 TBUFX2TS
Xfifo_from_fir_fifo_cell7_data_out_do_tri[27] fir_data_in[27]
+ fifo_from_fir_fifo_cell7_sr_out[27] FE_OFN1405_n8086 TBUFX2TS
Xfifo_from_fir_fifo_cell7_data_out_do_tri[26] fir_data_in[26]
+ fifo_from_fir_fifo_cell7_sr_out[26] FE_OFN1405_n8086 TBUFX2TS
Xfifo_from_fir_fifo_cell7_data_out_do_tri[25] fir_data_in[25]
+ fifo_from_fir_fifo_cell7_sr_out[25] FE_OFN1405_n8086 TBUFX2TS
Xfifo_from_fir_fifo_cell7_data_out_do_tri[24] fir_data_in[24]
+ fifo_from_fir_fifo_cell7_sr_out[24] FE_OFN1405_n8086 TBUFX2TS
Xfifo_from_fir_fifo_cell7_data_out_do_tri[23] fir_data_in[23]
+ fifo_from_fir_fifo_cell7_sr_out[23] FE_OFN1102_n2057 TBUFX2TS
Xfifo_from_fir_fifo_cell7_data_out_do_tri[22] fir_data_in[22]
+ fifo_from_fir_fifo_cell7_sr_out[22] FE_OFN1105_n2057 TBUFX2TS
Xfifo_from_fir_fifo_cell7_data_out_do_tri[21] fir_data_in[21]
+ fifo_from_fir_fifo_cell7_sr_out[21] n2057 TBUFX2TS
Xfifo_from_fir_fifo_cell7_data_out_do_tri[20] fir_data_in[20]
+ fifo_from_fir_fifo_cell7_sr_out[20] n2057 TBUFX2TS
Xfifo_from_fir_fifo_cell7_data_out_do_tri[19] fir_data_in[19]
+ fifo_from_fir_fifo_cell7_sr_out[19] n2057 TBUFX2TS
Xfifo_from_fir_fifo_cell7_data_out_do_tri[18] fir_data_in[18]
+ fifo_from_fir_fifo_cell7_sr_out[18] FE_OFN1103_n2057 TBUFX2TS
Xfifo_from_fir_fifo_cell7_data_out_do_tri[17] fir_data_in[17]
+ fifo_from_fir_fifo_cell7_sr_out[17] FE_OFN1102_n2057 TBUFX2TS
Xfifo_from_fir_fifo_cell7_data_out_do_tri[16] fir_data_in[16]
+ fifo_from_fir_fifo_cell7_sr_out[16] FE_OFN1102_n2057 TBUFX2TS
Xfifo_from_fir_fifo_cell7_data_out_do_tri[15] fir_data_in[15]
+ fifo_from_fir_fifo_cell7_sr_out[15] FE_OFN1105_n2057 TBUFX2TS
Xfifo_from_fir_fifo_cell7_data_out_do_tri[14] fir_data_in[14]
+ fifo_from_fir_fifo_cell7_sr_out[14] FE_OFN1105_n2057 TBUFX2TS
Xfifo_from_fir_fifo_cell7_data_out_do_tri[13] fir_data_in[13]
+ fifo_from_fir_fifo_cell7_sr_out[13] FE_OFN1103_n2057 TBUFX2TS
Xfifo_from_fir_fifo_cell7_data_out_do_tri[12] fir_data_in[12]
+ fifo_from_fir_fifo_cell7_sr_out[12] FE_OFN1105_n2057 TBUFX2TS
Xfifo_from_fir_fifo_cell7_data_out_do_tri[11] fir_data_in[11]
+ fifo_from_fir_fifo_cell7_sr_out[11] FE_OFN1104_n2057 TBUFX2TS
Xfifo_from_fir_fifo_cell7_data_out_do_tri[10] fir_data_in[10]
+ fifo_from_fir_fifo_cell7_sr_out[10] FE_OFN1104_n2057 TBUFX2TS
Xfifo_from_fir_fifo_cell7_data_out_do_tri[9] fir_data_in[9]
+ fifo_from_fir_fifo_cell7_sr_out[9] FE_OFN1104_n2057 TBUFX2TS
Xfifo_from_fir_fifo_cell7_data_out_do_tri[8] fir_data_in[8]
+ fifo_from_fir_fifo_cell7_sr_out[8] FE_OFN1103_n2057 TBUFX2TS
Xfifo_from_fir_fifo_cell7_data_out_do_tri[7] fir_data_in[7]
+ fifo_from_fir_fifo_cell7_sr_out[7] FE_OFN1403_n8086 TBUFX2TS
Xfifo_from_fir_fifo_cell7_data_out_do_tri[6] fir_data_in[6]
+ fifo_from_fir_fifo_cell7_sr_out[6] FE_OFN1404_n8086 TBUFX2TS
Xfifo_from_fir_fifo_cell7_data_out_do_tri[5] fir_data_in[5]
+ fifo_from_fir_fifo_cell7_sr_out[5] FE_OFN1404_n8086 TBUFX2TS
Xfifo_from_fir_fifo_cell7_data_out_do_tri[4] fir_data_in[4]
+ fifo_from_fir_fifo_cell7_sr_out[4] FE_OFN1403_n8086 TBUFX2TS
Xfifo_from_fir_fifo_cell7_data_out_do_tri[3] fir_data_in[3]
+ fifo_from_fir_fifo_cell7_sr_out[3] n8086 TBUFX2TS
Xfifo_from_fir_fifo_cell7_data_out_do_tri[2] fir_data_in[2]
+ fifo_from_fir_fifo_cell7_sr_out[2] FE_OFN1403_n8086 TBUFX2TS
Xfifo_from_fir_fifo_cell7_data_out_do_tri[1] fir_data_in[1]
+ fifo_from_fir_fifo_cell7_sr_out[1] n8086 TBUFX2TS
Xfifo_from_fir_fifo_cell7_data_out_do_tri[0] fir_data_in[0]
+ fifo_from_fir_fifo_cell7_sr_out[0] n8086 TBUFX2TS
Xfifo_from_fir_fifo_cell6_data_out_do_tri[31] fir_data_in[31]
+ fifo_from_fir_fifo_cell6_sr_out[31] FE_OFN1402_n8085 TBUFX2TS
Xfifo_from_fir_fifo_cell6_data_out_do_tri[30] fir_data_in[30]
+ fifo_from_fir_fifo_cell6_sr_out[30] FE_OFN1402_n8085 TBUFX2TS
Xfifo_from_fir_fifo_cell6_data_out_do_tri[29] fir_data_in[29]
+ fifo_from_fir_fifo_cell6_sr_out[29] FE_OFN1402_n8085 TBUFX2TS
Xfifo_from_fir_fifo_cell6_data_out_do_tri[28] fir_data_in[28]
+ fifo_from_fir_fifo_cell6_sr_out[28] FE_OFN1402_n8085 TBUFX2TS
Xfifo_from_fir_fifo_cell6_data_out_do_tri[27] fir_data_in[27]
+ fifo_from_fir_fifo_cell6_sr_out[27] FE_OFN1401_n8085 TBUFX2TS
Xfifo_from_fir_fifo_cell6_data_out_do_tri[26] fir_data_in[26]
+ fifo_from_fir_fifo_cell6_sr_out[26] FE_OFN1400_n8085 TBUFX2TS
Xfifo_from_fir_fifo_cell6_data_out_do_tri[25] fir_data_in[25]
+ fifo_from_fir_fifo_cell6_sr_out[25] FE_OFN1401_n8085 TBUFX2TS
Xfifo_from_fir_fifo_cell6_data_out_do_tri[24] fir_data_in[24]
+ fifo_from_fir_fifo_cell6_sr_out[24] FE_OFN1401_n8085 TBUFX2TS
Xfifo_from_fir_fifo_cell6_data_out_do_tri[23] fir_data_in[23]
+ fifo_from_fir_fifo_cell6_sr_out[23] FE_OFN1097_n1993 TBUFX2TS
Xfifo_from_fir_fifo_cell6_data_out_do_tri[22] fir_data_in[22]
+ fifo_from_fir_fifo_cell6_sr_out[22] FE_OFN1098_n1993 TBUFX2TS
Xfifo_from_fir_fifo_cell6_data_out_do_tri[21] fir_data_in[21]
+ fifo_from_fir_fifo_cell6_sr_out[21] FE_OFN1098_n1993 TBUFX2TS
Xfifo_from_fir_fifo_cell6_data_out_do_tri[20] fir_data_in[20]
+ fifo_from_fir_fifo_cell6_sr_out[20] n1993 TBUFX2TS
Xfifo_from_fir_fifo_cell6_data_out_do_tri[19] fir_data_in[19]
+ fifo_from_fir_fifo_cell6_sr_out[19] FE_OFN1097_n1993 TBUFX2TS
Xfifo_from_fir_fifo_cell6_data_out_do_tri[18] fir_data_in[18]
+ fifo_from_fir_fifo_cell6_sr_out[18] FE_OFN1099_n1993 TBUFX2TS
Xfifo_from_fir_fifo_cell6_data_out_do_tri[17] fir_data_in[17]
+ fifo_from_fir_fifo_cell6_sr_out[17] FE_OFN1099_n1993 TBUFX2TS
Xfifo_from_fir_fifo_cell6_data_out_do_tri[16] fir_data_in[16]
+ fifo_from_fir_fifo_cell6_sr_out[16] FE_OFN1099_n1993 TBUFX2TS
Xfifo_from_fir_fifo_cell6_data_out_do_tri[15] fir_data_in[15]
+ fifo_from_fir_fifo_cell6_sr_out[15] FE_OFN1100_n1993 TBUFX2TS
Xfifo_from_fir_fifo_cell6_data_out_do_tri[14] fir_data_in[14]
+ fifo_from_fir_fifo_cell6_sr_out[14] FE_OFN1100_n1993 TBUFX2TS
Xfifo_from_fir_fifo_cell6_data_out_do_tri[13] fir_data_in[13]
+ fifo_from_fir_fifo_cell6_sr_out[13] FE_OFN1099_n1993 TBUFX2TS
Xfifo_from_fir_fifo_cell6_data_out_do_tri[12] fir_data_in[12]
+ fifo_from_fir_fifo_cell6_sr_out[12] FE_OFN1098_n1993 TBUFX2TS
Xfifo_from_fir_fifo_cell6_data_out_do_tri[11] fir_data_in[11]
+ fifo_from_fir_fifo_cell6_sr_out[11] FE_OFN1101_n1993 TBUFX2TS
Xfifo_from_fir_fifo_cell6_data_out_do_tri[10] fir_data_in[10]
+ fifo_from_fir_fifo_cell6_sr_out[10] FE_OFN1101_n1993 TBUFX2TS
Xfifo_from_fir_fifo_cell6_data_out_do_tri[9] fir_data_in[9]
+ fifo_from_fir_fifo_cell6_sr_out[9] FE_OFN1101_n1993 TBUFX2TS
Xfifo_from_fir_fifo_cell6_data_out_do_tri[8] fir_data_in[8]
+ fifo_from_fir_fifo_cell6_sr_out[8] FE_OFN1101_n1993 TBUFX2TS
Xfifo_from_fir_fifo_cell6_data_out_do_tri[7] fir_data_in[7]
+ fifo_from_fir_fifo_cell6_sr_out[7] FE_OFN1399_n8085 TBUFX2TS
Xfifo_from_fir_fifo_cell6_data_out_do_tri[6] fir_data_in[6]
+ fifo_from_fir_fifo_cell6_sr_out[6] FE_OFN1399_n8085 TBUFX2TS
Xfifo_from_fir_fifo_cell6_data_out_do_tri[5] fir_data_in[5]
+ fifo_from_fir_fifo_cell6_sr_out[5] FE_OFN1400_n8085 TBUFX2TS
Xfifo_from_fir_fifo_cell6_data_out_do_tri[4] fir_data_in[4]
+ fifo_from_fir_fifo_cell6_sr_out[4] FE_OFN1400_n8085 TBUFX2TS
Xfifo_from_fir_fifo_cell6_data_out_do_tri[3] fir_data_in[3]
+ fifo_from_fir_fifo_cell6_sr_out[3] n8085 TBUFX2TS
Xfifo_from_fir_fifo_cell6_data_out_do_tri[2] fir_data_in[2]
+ fifo_from_fir_fifo_cell6_sr_out[2] FE_OFN1399_n8085 TBUFX2TS
Xfifo_from_fir_fifo_cell6_data_out_do_tri[1] fir_data_in[1]
+ fifo_from_fir_fifo_cell6_sr_out[1] n8085 TBUFX2TS
Xfifo_from_fir_fifo_cell6_data_out_do_tri[0] fir_data_in[0]
+ fifo_from_fir_fifo_cell6_sr_out[0] n8085 TBUFX2TS
Xfifo_from_fir_fifo_cell5_data_out_do_tri[31] fir_data_in[31]
+ fifo_from_fir_fifo_cell5_sr_out[31] FE_OFN1396_n8084 TBUFX2TS
Xfifo_from_fir_fifo_cell5_data_out_do_tri[30] fir_data_in[30]
+ fifo_from_fir_fifo_cell5_sr_out[30] FE_OFN1397_n8084 TBUFX2TS
Xfifo_from_fir_fifo_cell5_data_out_do_tri[29] fir_data_in[29]
+ fifo_from_fir_fifo_cell5_sr_out[29] FE_OFN1397_n8084 TBUFX2TS
Xfifo_from_fir_fifo_cell5_data_out_do_tri[28] fir_data_in[28]
+ fifo_from_fir_fifo_cell5_sr_out[28] FE_OFN1397_n8084 TBUFX2TS
Xfifo_from_fir_fifo_cell5_data_out_do_tri[27] fir_data_in[27]
+ fifo_from_fir_fifo_cell5_sr_out[27] FE_OFN1398_n8084 TBUFX2TS
Xfifo_from_fir_fifo_cell5_data_out_do_tri[26] fir_data_in[26]
+ fifo_from_fir_fifo_cell5_sr_out[26] FE_OFN1398_n8084 TBUFX2TS
Xfifo_from_fir_fifo_cell5_data_out_do_tri[25] fir_data_in[25]
+ fifo_from_fir_fifo_cell5_sr_out[25] FE_OFN1398_n8084 TBUFX2TS
Xfifo_from_fir_fifo_cell5_data_out_do_tri[24] fir_data_in[24]
+ fifo_from_fir_fifo_cell5_sr_out[24] FE_OFN1398_n8084 TBUFX2TS
Xfifo_from_fir_fifo_cell5_data_out_do_tri[23] fir_data_in[23]
+ fifo_from_fir_fifo_cell5_sr_out[23] FE_OFN1093_n1929 TBUFX2TS
Xfifo_from_fir_fifo_cell5_data_out_do_tri[22] fir_data_in[22]
+ fifo_from_fir_fifo_cell5_sr_out[22] FE_OFN1096_n1929 TBUFX2TS
Xfifo_from_fir_fifo_cell5_data_out_do_tri[21] fir_data_in[21]
+ fifo_from_fir_fifo_cell5_sr_out[21] n1929 TBUFX2TS
Xfifo_from_fir_fifo_cell5_data_out_do_tri[20] fir_data_in[20]
+ fifo_from_fir_fifo_cell5_sr_out[20] n1929 TBUFX2TS
Xfifo_from_fir_fifo_cell5_data_out_do_tri[19] fir_data_in[19]
+ fifo_from_fir_fifo_cell5_sr_out[19] n1929 TBUFX2TS
Xfifo_from_fir_fifo_cell5_data_out_do_tri[18] fir_data_in[18]
+ fifo_from_fir_fifo_cell5_sr_out[18] FE_OFN1094_n1929 TBUFX2TS
Xfifo_from_fir_fifo_cell5_data_out_do_tri[17] fir_data_in[17]
+ fifo_from_fir_fifo_cell5_sr_out[17] FE_OFN1093_n1929 TBUFX2TS
Xfifo_from_fir_fifo_cell5_data_out_do_tri[16] fir_data_in[16]
+ fifo_from_fir_fifo_cell5_sr_out[16] FE_OFN1093_n1929 TBUFX2TS
Xfifo_from_fir_fifo_cell5_data_out_do_tri[15] fir_data_in[15]
+ fifo_from_fir_fifo_cell5_sr_out[15] FE_OFN1096_n1929 TBUFX2TS
Xfifo_from_fir_fifo_cell5_data_out_do_tri[14] fir_data_in[14]
+ fifo_from_fir_fifo_cell5_sr_out[14] FE_OFN1096_n1929 TBUFX2TS
Xfifo_from_fir_fifo_cell5_data_out_do_tri[13] fir_data_in[13]
+ fifo_from_fir_fifo_cell5_sr_out[13] FE_OFN1094_n1929 TBUFX2TS
Xfifo_from_fir_fifo_cell5_data_out_do_tri[12] fir_data_in[12]
+ fifo_from_fir_fifo_cell5_sr_out[12] FE_OFN1096_n1929 TBUFX2TS
Xfifo_from_fir_fifo_cell5_data_out_do_tri[11] fir_data_in[11]
+ fifo_from_fir_fifo_cell5_sr_out[11] FE_OFN1094_n1929 TBUFX2TS
Xfifo_from_fir_fifo_cell5_data_out_do_tri[10] fir_data_in[10]
+ fifo_from_fir_fifo_cell5_sr_out[10] FE_OFN1095_n1929 TBUFX2TS
Xfifo_from_fir_fifo_cell5_data_out_do_tri[9] fir_data_in[9]
+ fifo_from_fir_fifo_cell5_sr_out[9] FE_OFN1095_n1929 TBUFX2TS
Xfifo_from_fir_fifo_cell5_data_out_do_tri[8] fir_data_in[8]
+ fifo_from_fir_fifo_cell5_sr_out[8] FE_OFN1095_n1929 TBUFX2TS
Xfifo_from_fir_fifo_cell5_data_out_do_tri[7] fir_data_in[7]
+ fifo_from_fir_fifo_cell5_sr_out[7] FE_OFN1395_n8084 TBUFX2TS
Xfifo_from_fir_fifo_cell5_data_out_do_tri[6] fir_data_in[6]
+ fifo_from_fir_fifo_cell5_sr_out[6] FE_OFN1396_n8084 TBUFX2TS
Xfifo_from_fir_fifo_cell5_data_out_do_tri[5] fir_data_in[5]
+ fifo_from_fir_fifo_cell5_sr_out[5] FE_OFN1395_n8084 TBUFX2TS
Xfifo_from_fir_fifo_cell5_data_out_do_tri[4] fir_data_in[4]
+ fifo_from_fir_fifo_cell5_sr_out[4] FE_OFN1395_n8084 TBUFX2TS
Xfifo_from_fir_fifo_cell5_data_out_do_tri[3] fir_data_in[3]
+ fifo_from_fir_fifo_cell5_sr_out[3] FE_OFN1394_n8084 TBUFX2TS
Xfifo_from_fir_fifo_cell5_data_out_do_tri[2] fir_data_in[2]
+ fifo_from_fir_fifo_cell5_sr_out[2] FE_OFN1394_n8084 TBUFX2TS
Xfifo_from_fir_fifo_cell5_data_out_do_tri[1] fir_data_in[1]
+ fifo_from_fir_fifo_cell5_sr_out[1] n8084 TBUFX2TS
Xfifo_from_fir_fifo_cell5_data_out_do_tri[0] fir_data_in[0]
+ fifo_from_fir_fifo_cell5_sr_out[0] FE_OFN1394_n8084 TBUFX2TS
Xfifo_from_fir_fifo_cell4_data_out_do_tri[31] fir_data_in[31]
+ fifo_from_fir_fifo_cell4_sr_out[31] FE_OFN1393_n8083 TBUFX2TS
Xfifo_from_fir_fifo_cell4_data_out_do_tri[30] fir_data_in[30]
+ fifo_from_fir_fifo_cell4_sr_out[30] FE_OFN1391_n8083 TBUFX2TS
Xfifo_from_fir_fifo_cell4_data_out_do_tri[29] fir_data_in[29]
+ fifo_from_fir_fifo_cell4_sr_out[29] FE_OFN1393_n8083 TBUFX2TS
Xfifo_from_fir_fifo_cell4_data_out_do_tri[28] fir_data_in[28]
+ fifo_from_fir_fifo_cell4_sr_out[28] FE_OFN1393_n8083 TBUFX2TS
Xfifo_from_fir_fifo_cell4_data_out_do_tri[27] fir_data_in[27]
+ fifo_from_fir_fifo_cell4_sr_out[27] FE_OFN1391_n8083 TBUFX2TS
Xfifo_from_fir_fifo_cell4_data_out_do_tri[26] fir_data_in[26]
+ fifo_from_fir_fifo_cell4_sr_out[26] FE_OFN1392_n8083 TBUFX2TS
Xfifo_from_fir_fifo_cell4_data_out_do_tri[25] fir_data_in[25]
+ fifo_from_fir_fifo_cell4_sr_out[25] FE_OFN1392_n8083 TBUFX2TS
Xfifo_from_fir_fifo_cell4_data_out_do_tri[24] fir_data_in[24]
+ fifo_from_fir_fifo_cell4_sr_out[24] FE_OFN1392_n8083 TBUFX2TS
Xfifo_from_fir_fifo_cell4_data_out_do_tri[23] fir_data_in[23]
+ fifo_from_fir_fifo_cell4_sr_out[23] n1865 TBUFX2TS
Xfifo_from_fir_fifo_cell4_data_out_do_tri[22] fir_data_in[22]
+ fifo_from_fir_fifo_cell4_sr_out[22] FE_OFN1092_n1865 TBUFX2TS
Xfifo_from_fir_fifo_cell4_data_out_do_tri[21] fir_data_in[21]
+ fifo_from_fir_fifo_cell4_sr_out[21] n1865 TBUFX2TS
Xfifo_from_fir_fifo_cell4_data_out_do_tri[20] fir_data_in[20]
+ fifo_from_fir_fifo_cell4_sr_out[20] n1865 TBUFX2TS
Xfifo_from_fir_fifo_cell4_data_out_do_tri[19] fir_data_in[19]
+ fifo_from_fir_fifo_cell4_sr_out[19] FE_OFN1089_n1865 TBUFX2TS
Xfifo_from_fir_fifo_cell4_data_out_do_tri[18] fir_data_in[18]
+ fifo_from_fir_fifo_cell4_sr_out[18] FE_OFN1090_n1865 TBUFX2TS
Xfifo_from_fir_fifo_cell4_data_out_do_tri[17] fir_data_in[17]
+ fifo_from_fir_fifo_cell4_sr_out[17] FE_OFN1089_n1865 TBUFX2TS
Xfifo_from_fir_fifo_cell4_data_out_do_tri[16] fir_data_in[16]
+ fifo_from_fir_fifo_cell4_sr_out[16] FE_OFN1089_n1865 TBUFX2TS
Xfifo_from_fir_fifo_cell4_data_out_do_tri[15] fir_data_in[15]
+ fifo_from_fir_fifo_cell4_sr_out[15] FE_OFN1092_n1865 TBUFX2TS
Xfifo_from_fir_fifo_cell4_data_out_do_tri[14] fir_data_in[14]
+ fifo_from_fir_fifo_cell4_sr_out[14] FE_OFN1092_n1865 TBUFX2TS
Xfifo_from_fir_fifo_cell4_data_out_do_tri[13] fir_data_in[13]
+ fifo_from_fir_fifo_cell4_sr_out[13] FE_OFN1090_n1865 TBUFX2TS
Xfifo_from_fir_fifo_cell4_data_out_do_tri[12] fir_data_in[12]
+ fifo_from_fir_fifo_cell4_sr_out[12] FE_OFN1092_n1865 TBUFX2TS
Xfifo_from_fir_fifo_cell4_data_out_do_tri[11] fir_data_in[11]
+ fifo_from_fir_fifo_cell4_sr_out[11] FE_OFN1090_n1865 TBUFX2TS
Xfifo_from_fir_fifo_cell4_data_out_do_tri[10] fir_data_in[10]
+ fifo_from_fir_fifo_cell4_sr_out[10] FE_OFN1091_n1865 TBUFX2TS
Xfifo_from_fir_fifo_cell4_data_out_do_tri[9] fir_data_in[9]
+ fifo_from_fir_fifo_cell4_sr_out[9] FE_OFN1091_n1865 TBUFX2TS
Xfifo_from_fir_fifo_cell4_data_out_do_tri[8] fir_data_in[8]
+ fifo_from_fir_fifo_cell4_sr_out[8] FE_OFN1091_n1865 TBUFX2TS
Xfifo_from_fir_fifo_cell4_data_out_do_tri[7] fir_data_in[7]
+ fifo_from_fir_fifo_cell4_sr_out[7] FE_OFN1390_n8083 TBUFX2TS
Xfifo_from_fir_fifo_cell4_data_out_do_tri[6] fir_data_in[6]
+ fifo_from_fir_fifo_cell4_sr_out[6] FE_OFN1393_n8083 TBUFX2TS
Xfifo_from_fir_fifo_cell4_data_out_do_tri[5] fir_data_in[5]
+ fifo_from_fir_fifo_cell4_sr_out[5] FE_OFN1390_n8083 TBUFX2TS
Xfifo_from_fir_fifo_cell4_data_out_do_tri[4] fir_data_in[4]
+ fifo_from_fir_fifo_cell4_sr_out[4] n8083 TBUFX2TS
Xfifo_from_fir_fifo_cell4_data_out_do_tri[3] fir_data_in[3]
+ fifo_from_fir_fifo_cell4_sr_out[3] FE_OFN1389_n8083 TBUFX2TS
Xfifo_from_fir_fifo_cell4_data_out_do_tri[2] fir_data_in[2]
+ fifo_from_fir_fifo_cell4_sr_out[2] FE_OFN1390_n8083 TBUFX2TS
Xfifo_from_fir_fifo_cell4_data_out_do_tri[1] fir_data_in[1]
+ fifo_from_fir_fifo_cell4_sr_out[1] FE_OFN1389_n8083 TBUFX2TS
Xfifo_from_fir_fifo_cell4_data_out_do_tri[0] fir_data_in[0]
+ fifo_from_fir_fifo_cell4_sr_out[0] FE_OFN1389_n8083 TBUFX2TS
Xfifo_from_fir_fifo_cell3_data_out_do_tri[31] fir_data_in[31]
+ fifo_from_fir_fifo_cell3_sr_out[31] FE_OFN1388_n8082 TBUFX2TS
Xfifo_from_fir_fifo_cell3_data_out_do_tri[30] fir_data_in[30]
+ fifo_from_fir_fifo_cell3_sr_out[30] FE_OFN1388_n8082 TBUFX2TS
Xfifo_from_fir_fifo_cell3_data_out_do_tri[29] fir_data_in[29]
+ fifo_from_fir_fifo_cell3_sr_out[29] FE_OFN1388_n8082 TBUFX2TS
Xfifo_from_fir_fifo_cell3_data_out_do_tri[28] fir_data_in[28]
+ fifo_from_fir_fifo_cell3_sr_out[28] FE_OFN1388_n8082 TBUFX2TS
Xfifo_from_fir_fifo_cell3_data_out_do_tri[27] fir_data_in[27]
+ fifo_from_fir_fifo_cell3_sr_out[27] FE_OFN1387_n8082 TBUFX2TS
Xfifo_from_fir_fifo_cell3_data_out_do_tri[26] fir_data_in[26]
+ fifo_from_fir_fifo_cell3_sr_out[26] FE_OFN1387_n8082 TBUFX2TS
Xfifo_from_fir_fifo_cell3_data_out_do_tri[25] fir_data_in[25]
+ fifo_from_fir_fifo_cell3_sr_out[25] FE_OFN1385_n8082 TBUFX2TS
Xfifo_from_fir_fifo_cell3_data_out_do_tri[24] fir_data_in[24]
+ fifo_from_fir_fifo_cell3_sr_out[24] FE_OFN1385_n8082 TBUFX2TS
Xfifo_from_fir_fifo_cell3_data_out_do_tri[23] fir_data_in[23]
+ fifo_from_fir_fifo_cell3_sr_out[23] FE_OFN1085_n1801 TBUFX2TS
Xfifo_from_fir_fifo_cell3_data_out_do_tri[22] fir_data_in[22]
+ fifo_from_fir_fifo_cell3_sr_out[22] FE_OFN1088_n1801 TBUFX2TS
Xfifo_from_fir_fifo_cell3_data_out_do_tri[21] fir_data_in[21]
+ fifo_from_fir_fifo_cell3_sr_out[21] n1801 TBUFX2TS
Xfifo_from_fir_fifo_cell3_data_out_do_tri[20] fir_data_in[20]
+ fifo_from_fir_fifo_cell3_sr_out[20] n1801 TBUFX2TS
Xfifo_from_fir_fifo_cell3_data_out_do_tri[19] fir_data_in[19]
+ fifo_from_fir_fifo_cell3_sr_out[19] n1801 TBUFX2TS
Xfifo_from_fir_fifo_cell3_data_out_do_tri[18] fir_data_in[18]
+ fifo_from_fir_fifo_cell3_sr_out[18] FE_OFN1086_n1801 TBUFX2TS
Xfifo_from_fir_fifo_cell3_data_out_do_tri[17] fir_data_in[17]
+ fifo_from_fir_fifo_cell3_sr_out[17] FE_OFN1085_n1801 TBUFX2TS
Xfifo_from_fir_fifo_cell3_data_out_do_tri[16] fir_data_in[16]
+ fifo_from_fir_fifo_cell3_sr_out[16] FE_OFN1085_n1801 TBUFX2TS
Xfifo_from_fir_fifo_cell3_data_out_do_tri[15] fir_data_in[15]
+ fifo_from_fir_fifo_cell3_sr_out[15] FE_OFN1088_n1801 TBUFX2TS
Xfifo_from_fir_fifo_cell3_data_out_do_tri[14] fir_data_in[14]
+ fifo_from_fir_fifo_cell3_sr_out[14] FE_OFN1088_n1801 TBUFX2TS
Xfifo_from_fir_fifo_cell3_data_out_do_tri[13] fir_data_in[13]
+ fifo_from_fir_fifo_cell3_sr_out[13] FE_OFN1086_n1801 TBUFX2TS
Xfifo_from_fir_fifo_cell3_data_out_do_tri[12] fir_data_in[12]
+ fifo_from_fir_fifo_cell3_sr_out[12] FE_OFN1088_n1801 TBUFX2TS
Xfifo_from_fir_fifo_cell3_data_out_do_tri[11] fir_data_in[11]
+ fifo_from_fir_fifo_cell3_sr_out[11] FE_OFN1086_n1801 TBUFX2TS
Xfifo_from_fir_fifo_cell3_data_out_do_tri[10] fir_data_in[10]
+ fifo_from_fir_fifo_cell3_sr_out[10] FE_OFN1087_n1801 TBUFX2TS
Xfifo_from_fir_fifo_cell3_data_out_do_tri[9] fir_data_in[9]
+ fifo_from_fir_fifo_cell3_sr_out[9] FE_OFN1087_n1801 TBUFX2TS
Xfifo_from_fir_fifo_cell3_data_out_do_tri[8] fir_data_in[8]
+ fifo_from_fir_fifo_cell3_sr_out[8] FE_OFN1087_n1801 TBUFX2TS
Xfifo_from_fir_fifo_cell3_data_out_do_tri[7] fir_data_in[7]
+ fifo_from_fir_fifo_cell3_sr_out[7] FE_OFN1384_n8082 TBUFX2TS
Xfifo_from_fir_fifo_cell3_data_out_do_tri[6] fir_data_in[6]
+ fifo_from_fir_fifo_cell3_sr_out[6] FE_OFN1384_n8082 TBUFX2TS
Xfifo_from_fir_fifo_cell3_data_out_do_tri[5] fir_data_in[5]
+ fifo_from_fir_fifo_cell3_sr_out[5] FE_OFN1385_n8082 TBUFX2TS
Xfifo_from_fir_fifo_cell3_data_out_do_tri[4] fir_data_in[4]
+ fifo_from_fir_fifo_cell3_sr_out[4] FE_OFN1384_n8082 TBUFX2TS
Xfifo_from_fir_fifo_cell3_data_out_do_tri[3] fir_data_in[3]
+ fifo_from_fir_fifo_cell3_sr_out[3] FE_OFN1386_n8082 TBUFX2TS
Xfifo_from_fir_fifo_cell3_data_out_do_tri[2] fir_data_in[2]
+ fifo_from_fir_fifo_cell3_sr_out[2] FE_OFN1386_n8082 TBUFX2TS
Xfifo_from_fir_fifo_cell3_data_out_do_tri[1] fir_data_in[1]
+ fifo_from_fir_fifo_cell3_sr_out[1] FE_OFN1386_n8082 TBUFX2TS
Xfifo_from_fir_fifo_cell3_data_out_do_tri[0] fir_data_in[0]
+ fifo_from_fir_fifo_cell3_sr_out[0] FE_OFN1386_n8082 TBUFX2TS
Xfifo_from_fir_fifo_cell2_data_out_do_tri[31] fir_data_in[31]
+ fifo_from_fir_fifo_cell2_sr_out[31] FE_OFN1382_n8081 TBUFX2TS
Xfifo_from_fir_fifo_cell2_data_out_do_tri[30] fir_data_in[30]
+ fifo_from_fir_fifo_cell2_sr_out[30] FE_OFN1382_n8081 TBUFX2TS
Xfifo_from_fir_fifo_cell2_data_out_do_tri[29] fir_data_in[29]
+ fifo_from_fir_fifo_cell2_sr_out[29] FE_OFN1382_n8081 TBUFX2TS
Xfifo_from_fir_fifo_cell2_data_out_do_tri[28] fir_data_in[28]
+ fifo_from_fir_fifo_cell2_sr_out[28] FE_OFN1382_n8081 TBUFX2TS
Xfifo_from_fir_fifo_cell2_data_out_do_tri[27] fir_data_in[27]
+ fifo_from_fir_fifo_cell2_sr_out[27] FE_OFN1380_n8081 TBUFX2TS
Xfifo_from_fir_fifo_cell2_data_out_do_tri[26] fir_data_in[26]
+ fifo_from_fir_fifo_cell2_sr_out[26] FE_OFN1380_n8081 TBUFX2TS
Xfifo_from_fir_fifo_cell2_data_out_do_tri[25] fir_data_in[25]
+ fifo_from_fir_fifo_cell2_sr_out[25] n8081 TBUFX2TS
Xfifo_from_fir_fifo_cell2_data_out_do_tri[24] fir_data_in[24]
+ fifo_from_fir_fifo_cell2_sr_out[24] FE_OFN1380_n8081 TBUFX2TS
Xfifo_from_fir_fifo_cell2_data_out_do_tri[23] fir_data_in[23]
+ fifo_from_fir_fifo_cell2_sr_out[23] n1737 TBUFX2TS
Xfifo_from_fir_fifo_cell2_data_out_do_tri[22] fir_data_in[22]
+ fifo_from_fir_fifo_cell2_sr_out[22] FE_OFN1083_n1737 TBUFX2TS
Xfifo_from_fir_fifo_cell2_data_out_do_tri[21] fir_data_in[21]
+ fifo_from_fir_fifo_cell2_sr_out[21] FE_OFN1083_n1737 TBUFX2TS
Xfifo_from_fir_fifo_cell2_data_out_do_tri[20] fir_data_in[20]
+ fifo_from_fir_fifo_cell2_sr_out[20] n1737 TBUFX2TS
Xfifo_from_fir_fifo_cell2_data_out_do_tri[19] fir_data_in[19]
+ fifo_from_fir_fifo_cell2_sr_out[19] FE_OFN1082_n1737 TBUFX2TS
Xfifo_from_fir_fifo_cell2_data_out_do_tri[18] fir_data_in[18]
+ fifo_from_fir_fifo_cell2_sr_out[18] FE_OFN1082_n1737 TBUFX2TS
Xfifo_from_fir_fifo_cell2_data_out_do_tri[17] fir_data_in[17]
+ fifo_from_fir_fifo_cell2_sr_out[17] FE_OFN1082_n1737 TBUFX2TS
Xfifo_from_fir_fifo_cell2_data_out_do_tri[16] fir_data_in[16]
+ fifo_from_fir_fifo_cell2_sr_out[16] FE_OFN1082_n1737 TBUFX2TS
Xfifo_from_fir_fifo_cell2_data_out_do_tri[15] fir_data_in[15]
+ fifo_from_fir_fifo_cell2_sr_out[15] FE_OFN1081_n1737 TBUFX2TS
Xfifo_from_fir_fifo_cell2_data_out_do_tri[14] fir_data_in[14]
+ fifo_from_fir_fifo_cell2_sr_out[14] FE_OFN1083_n1737 TBUFX2TS
Xfifo_from_fir_fifo_cell2_data_out_do_tri[13] fir_data_in[13]
+ fifo_from_fir_fifo_cell2_sr_out[13] FE_OFN1081_n1737 TBUFX2TS
Xfifo_from_fir_fifo_cell2_data_out_do_tri[12] fir_data_in[12]
+ fifo_from_fir_fifo_cell2_sr_out[12] FE_OFN1083_n1737 TBUFX2TS
Xfifo_from_fir_fifo_cell2_data_out_do_tri[11] fir_data_in[11]
+ fifo_from_fir_fifo_cell2_sr_out[11] FE_OFN1084_n1737 TBUFX2TS
Xfifo_from_fir_fifo_cell2_data_out_do_tri[10] fir_data_in[10]
+ fifo_from_fir_fifo_cell2_sr_out[10] FE_OFN1084_n1737 TBUFX2TS
Xfifo_from_fir_fifo_cell2_data_out_do_tri[9] fir_data_in[9]
+ fifo_from_fir_fifo_cell2_sr_out[9] FE_OFN1084_n1737 TBUFX2TS
Xfifo_from_fir_fifo_cell2_data_out_do_tri[8] fir_data_in[8]
+ fifo_from_fir_fifo_cell2_sr_out[8] FE_OFN1084_n1737 TBUFX2TS
Xfifo_from_fir_fifo_cell2_data_out_do_tri[7] fir_data_in[7]
+ fifo_from_fir_fifo_cell2_sr_out[7] FE_OFN1381_n8081 TBUFX2TS
Xfifo_from_fir_fifo_cell2_data_out_do_tri[6] fir_data_in[6]
+ fifo_from_fir_fifo_cell2_sr_out[6] FE_OFN1381_n8081 TBUFX2TS
Xfifo_from_fir_fifo_cell2_data_out_do_tri[5] fir_data_in[5]
+ fifo_from_fir_fifo_cell2_sr_out[5] n8081 TBUFX2TS
Xfifo_from_fir_fifo_cell2_data_out_do_tri[4] fir_data_in[4]
+ fifo_from_fir_fifo_cell2_sr_out[4] FE_OFN1381_n8081 TBUFX2TS
Xfifo_from_fir_fifo_cell2_data_out_do_tri[3] fir_data_in[3]
+ fifo_from_fir_fifo_cell2_sr_out[3] FE_OFN1383_n8081 TBUFX2TS
Xfifo_from_fir_fifo_cell2_data_out_do_tri[2] fir_data_in[2]
+ fifo_from_fir_fifo_cell2_sr_out[2] FE_OFN1383_n8081 TBUFX2TS
Xfifo_from_fir_fifo_cell2_data_out_do_tri[1] fir_data_in[1]
+ fifo_from_fir_fifo_cell2_sr_out[1] FE_OFN1383_n8081 TBUFX2TS
Xfifo_from_fir_fifo_cell2_data_out_do_tri[0] fir_data_in[0]
+ fifo_from_fir_fifo_cell2_sr_out[0] FE_OFN1383_n8081 TBUFX2TS
Xfifo_from_fir_fifo_cell1_data_out_do_tri[31] fir_data_in[31]
+ fifo_from_fir_fifo_cell1_sr_out[31] FE_OFN1379_n8080 TBUFX2TS
Xfifo_from_fir_fifo_cell1_data_out_do_tri[30] fir_data_in[30]
+ fifo_from_fir_fifo_cell1_sr_out[30] FE_OFN1379_n8080 TBUFX2TS
Xfifo_from_fir_fifo_cell1_data_out_do_tri[29] fir_data_in[29]
+ fifo_from_fir_fifo_cell1_sr_out[29] FE_OFN1379_n8080 TBUFX2TS
Xfifo_from_fir_fifo_cell1_data_out_do_tri[28] fir_data_in[28]
+ fifo_from_fir_fifo_cell1_sr_out[28] FE_OFN1379_n8080 TBUFX2TS
Xfifo_from_fir_fifo_cell1_data_out_do_tri[27] fir_data_in[27]
+ fifo_from_fir_fifo_cell1_sr_out[27] FE_OFN1376_n8080 TBUFX2TS
Xfifo_from_fir_fifo_cell1_data_out_do_tri[26] fir_data_in[26]
+ fifo_from_fir_fifo_cell1_sr_out[26] FE_OFN1378_n8080 TBUFX2TS
Xfifo_from_fir_fifo_cell1_data_out_do_tri[25] fir_data_in[25]
+ fifo_from_fir_fifo_cell1_sr_out[25] FE_OFN1378_n8080 TBUFX2TS
Xfifo_from_fir_fifo_cell1_data_out_do_tri[24] fir_data_in[24]
+ fifo_from_fir_fifo_cell1_sr_out[24] FE_OFN1378_n8080 TBUFX2TS
Xfifo_from_fir_fifo_cell1_data_out_do_tri[23] fir_data_in[23]
+ fifo_from_fir_fifo_cell1_sr_out[23] FE_OFN1077_n1673 TBUFX2TS
Xfifo_from_fir_fifo_cell1_data_out_do_tri[22] fir_data_in[22]
+ fifo_from_fir_fifo_cell1_sr_out[22] FE_OFN1079_n1673 TBUFX2TS
Xfifo_from_fir_fifo_cell1_data_out_do_tri[21] fir_data_in[21]
+ fifo_from_fir_fifo_cell1_sr_out[21] FE_OFN1077_n1673 TBUFX2TS
Xfifo_from_fir_fifo_cell1_data_out_do_tri[20] fir_data_in[20]
+ fifo_from_fir_fifo_cell1_sr_out[20] n1673 TBUFX2TS
Xfifo_from_fir_fifo_cell1_data_out_do_tri[19] fir_data_in[19]
+ fifo_from_fir_fifo_cell1_sr_out[19] n1673 TBUFX2TS
Xfifo_from_fir_fifo_cell1_data_out_do_tri[18] fir_data_in[18]
+ fifo_from_fir_fifo_cell1_sr_out[18] FE_OFN1080_n1673 TBUFX2TS
Xfifo_from_fir_fifo_cell1_data_out_do_tri[17] fir_data_in[17]
+ fifo_from_fir_fifo_cell1_sr_out[17] n1673 TBUFX2TS
Xfifo_from_fir_fifo_cell1_data_out_do_tri[16] fir_data_in[16]
+ fifo_from_fir_fifo_cell1_sr_out[16] FE_OFN1078_n1673 TBUFX2TS
Xfifo_from_fir_fifo_cell1_data_out_do_tri[15] fir_data_in[15]
+ fifo_from_fir_fifo_cell1_sr_out[15] FE_OFN1078_n1673 TBUFX2TS
Xfifo_from_fir_fifo_cell1_data_out_do_tri[14] fir_data_in[14]
+ fifo_from_fir_fifo_cell1_sr_out[14] FE_OFN1079_n1673 TBUFX2TS
Xfifo_from_fir_fifo_cell1_data_out_do_tri[13] fir_data_in[13]
+ fifo_from_fir_fifo_cell1_sr_out[13] FE_OFN1078_n1673 TBUFX2TS
Xfifo_from_fir_fifo_cell1_data_out_do_tri[12] fir_data_in[12]
+ fifo_from_fir_fifo_cell1_sr_out[12] FE_OFN1079_n1673 TBUFX2TS
Xfifo_from_fir_fifo_cell1_data_out_do_tri[11] fir_data_in[11]
+ fifo_from_fir_fifo_cell1_sr_out[11] FE_OFN1080_n1673 TBUFX2TS
Xfifo_from_fir_fifo_cell1_data_out_do_tri[10] fir_data_in[10]
+ fifo_from_fir_fifo_cell1_sr_out[10] FE_OFN1079_n1673 TBUFX2TS
Xfifo_from_fir_fifo_cell1_data_out_do_tri[9] fir_data_in[9]
+ fifo_from_fir_fifo_cell1_sr_out[9] FE_OFN1080_n1673 TBUFX2TS
Xfifo_from_fir_fifo_cell1_data_out_do_tri[8] fir_data_in[8]
+ fifo_from_fir_fifo_cell1_sr_out[8] FE_OFN1080_n1673 TBUFX2TS
Xfifo_from_fir_fifo_cell1_data_out_do_tri[7] fir_data_in[7]
+ fifo_from_fir_fifo_cell1_sr_out[7] n8080 TBUFX2TS
Xfifo_from_fir_fifo_cell1_data_out_do_tri[6] fir_data_in[6]
+ fifo_from_fir_fifo_cell1_sr_out[6] FE_OFN1376_n8080 TBUFX2TS
Xfifo_from_fir_fifo_cell1_data_out_do_tri[5] fir_data_in[5]
+ fifo_from_fir_fifo_cell1_sr_out[5] FE_OFN1376_n8080 TBUFX2TS
Xfifo_from_fir_fifo_cell1_data_out_do_tri[4] fir_data_in[4]
+ fifo_from_fir_fifo_cell1_sr_out[4] n8080 TBUFX2TS
Xfifo_from_fir_fifo_cell1_data_out_do_tri[3] fir_data_in[3]
+ fifo_from_fir_fifo_cell1_sr_out[3] FE_OFN1377_n8080 TBUFX2TS
Xfifo_from_fir_fifo_cell1_data_out_do_tri[2] fir_data_in[2]
+ fifo_from_fir_fifo_cell1_sr_out[2] FE_OFN1377_n8080 TBUFX2TS
Xfifo_from_fir_fifo_cell1_data_out_do_tri[1] fir_data_in[1]
+ fifo_from_fir_fifo_cell1_sr_out[1] FE_OFN1377_n8080 TBUFX2TS
Xfifo_from_fir_fifo_cell1_data_out_do_tri[0] fir_data_in[0]
+ fifo_from_fir_fifo_cell1_sr_out[0] FE_OFN1377_n8080 TBUFX2TS
Xfifo_from_fir_fifo_cell0_data_out_do_tri[31] fir_data_in[31]
+ fifo_from_fir_fifo_cell0_sr_out[31] FE_OFN1150_n1609 TBUFX2TS
Xfifo_from_fir_fifo_cell0_data_out_do_tri[30] fir_data_in[30]
+ fifo_from_fir_fifo_cell0_sr_out[30] FE_OFN1150_n1609 TBUFX2TS
Xfifo_from_fir_fifo_cell0_data_out_do_tri[29] fir_data_in[29]
+ fifo_from_fir_fifo_cell0_sr_out[29] FE_OFN1150_n1609 TBUFX2TS
Xfifo_from_fir_fifo_cell0_data_out_do_tri[28] fir_data_in[28]
+ fifo_from_fir_fifo_cell0_sr_out[28] FE_OFN1150_n1609 TBUFX2TS
Xfifo_from_fir_fifo_cell0_data_out_do_tri[27] fir_data_in[27]
+ fifo_from_fir_fifo_cell0_sr_out[27] FE_OFN1148_n1609 TBUFX2TS
Xfifo_from_fir_fifo_cell0_data_out_do_tri[26] fir_data_in[26]
+ fifo_from_fir_fifo_cell0_sr_out[26] FE_OFN1148_n1609 TBUFX2TS
Xfifo_from_fir_fifo_cell0_data_out_do_tri[25] fir_data_in[25]
+ fifo_from_fir_fifo_cell0_sr_out[25] n1609 TBUFX2TS
Xfifo_from_fir_fifo_cell0_data_out_do_tri[24] fir_data_in[24]
+ fifo_from_fir_fifo_cell0_sr_out[24] n1609 TBUFX2TS
Xfifo_from_fir_fifo_cell0_data_out_do_tri[23] fir_data_in[23]
+ fifo_from_fir_fifo_cell0_sr_out[23] FE_OFN1153_n1609 TBUFX2TS
Xfifo_from_fir_fifo_cell0_data_out_do_tri[22] fir_data_in[22]
+ fifo_from_fir_fifo_cell0_sr_out[22] FE_OFN1154_n1609 TBUFX2TS
Xfifo_from_fir_fifo_cell0_data_out_do_tri[21] fir_data_in[21]
+ fifo_from_fir_fifo_cell0_sr_out[21] FE_OFN1154_n1609 TBUFX2TS
Xfifo_from_fir_fifo_cell0_data_out_do_tri[20] fir_data_in[20]
+ fifo_from_fir_fifo_cell0_sr_out[20] FE_OFN1154_n1609 TBUFX2TS
Xfifo_from_fir_fifo_cell0_data_out_do_tri[19] fir_data_in[19]
+ fifo_from_fir_fifo_cell0_sr_out[19] FE_OFN1153_n1609 TBUFX2TS
Xfifo_from_fir_fifo_cell0_data_out_do_tri[18] fir_data_in[18]
+ fifo_from_fir_fifo_cell0_sr_out[18] FE_OFN1155_n1609 TBUFX2TS
Xfifo_from_fir_fifo_cell0_data_out_do_tri[17] fir_data_in[17]
+ fifo_from_fir_fifo_cell0_sr_out[17] FE_OFN1155_n1609 TBUFX2TS
Xfifo_from_fir_fifo_cell0_data_out_do_tri[16] fir_data_in[16]
+ fifo_from_fir_fifo_cell0_sr_out[16] FE_OFN1155_n1609 TBUFX2TS
Xfifo_from_fir_fifo_cell0_data_out_do_tri[15] fir_data_in[15]
+ fifo_from_fir_fifo_cell0_sr_out[15] FE_OFN1156_n1609 TBUFX2TS
Xfifo_from_fir_fifo_cell0_data_out_do_tri[14] fir_data_in[14]
+ fifo_from_fir_fifo_cell0_sr_out[14] FE_OFN1156_n1609 TBUFX2TS
Xfifo_from_fir_fifo_cell0_data_out_do_tri[13] fir_data_in[13]
+ fifo_from_fir_fifo_cell0_sr_out[13] FE_OFN1157_n1609 TBUFX2TS
Xfifo_from_fir_fifo_cell0_data_out_do_tri[12] fir_data_in[12]
+ fifo_from_fir_fifo_cell0_sr_out[12] FE_OFN1156_n1609 TBUFX2TS
Xfifo_from_fir_fifo_cell0_data_out_do_tri[11] fir_data_in[11]
+ fifo_from_fir_fifo_cell0_sr_out[11] FE_OFN1157_n1609 TBUFX2TS
Xfifo_from_fir_fifo_cell0_data_out_do_tri[10] fir_data_in[10]
+ fifo_from_fir_fifo_cell0_sr_out[10] FE_OFN1156_n1609 TBUFX2TS
Xfifo_from_fir_fifo_cell0_data_out_do_tri[9] fir_data_in[9]
+ fifo_from_fir_fifo_cell0_sr_out[9] FE_OFN1157_n1609 TBUFX2TS
Xfifo_from_fir_fifo_cell0_data_out_do_tri[8] fir_data_in[8]
+ fifo_from_fir_fifo_cell0_sr_out[8] FE_OFN1157_n1609 TBUFX2TS
Xfifo_from_fir_fifo_cell0_data_out_do_tri[7] fir_data_in[7]
+ fifo_from_fir_fifo_cell0_sr_out[7] FE_OFN1149_n1609 TBUFX2TS
Xfifo_from_fir_fifo_cell0_data_out_do_tri[6] fir_data_in[6]
+ fifo_from_fir_fifo_cell0_sr_out[6] FE_OFN1149_n1609 TBUFX2TS
Xfifo_from_fir_fifo_cell0_data_out_do_tri[5] fir_data_in[5]
+ fifo_from_fir_fifo_cell0_sr_out[5] FE_OFN1148_n1609 TBUFX2TS
Xfifo_from_fir_fifo_cell0_data_out_do_tri[4] fir_data_in[4]
+ fifo_from_fir_fifo_cell0_sr_out[4] FE_OFN1151_n1609 TBUFX2TS
Xfifo_from_fir_fifo_cell0_data_out_do_tri[3] fir_data_in[3]
+ fifo_from_fir_fifo_cell0_sr_out[3] FE_OFN1152_n1609 TBUFX2TS
Xfifo_from_fir_fifo_cell0_data_out_do_tri[2] fir_data_in[2]
+ fifo_from_fir_fifo_cell0_sr_out[2] FE_OFN1151_n1609 TBUFX2TS
Xfifo_from_fir_fifo_cell0_data_out_do_tri[1] fir_data_in[1]
+ fifo_from_fir_fifo_cell0_sr_out[1] FE_OFN1152_n1609 TBUFX2TS
Xfifo_from_fir_fifo_cell0_data_out_do_tri[0] fir_data_in[0]
+ fifo_from_fir_fifo_cell0_sr_out[0] FE_OFN1151_n1609 TBUFX2TS
Xfifo_from_fft_fifo_cell15_data_out_do_tri[31] fft_data_in[31]
+ fifo_from_fft_fifo_cell15_sr_out[31] FE_OFN1309_n8079 TBUFX2TS
Xfifo_from_fft_fifo_cell15_data_out_do_tri[30] fft_data_in[30]
+ fifo_from_fft_fifo_cell15_sr_out[30] FE_OFN1309_n8079 TBUFX2TS
Xfifo_from_fft_fifo_cell15_data_out_do_tri[29] fft_data_in[29]
+ fifo_from_fft_fifo_cell15_sr_out[29] FE_OFN1309_n8079 TBUFX2TS
Xfifo_from_fft_fifo_cell15_data_out_do_tri[28] fft_data_in[28]
+ fifo_from_fft_fifo_cell15_sr_out[28] FE_OFN1309_n8079 TBUFX2TS
Xfifo_from_fft_fifo_cell15_data_out_do_tri[27] fft_data_in[27]
+ fifo_from_fft_fifo_cell15_sr_out[27] FE_OFN1307_n8079 TBUFX2TS
Xfifo_from_fft_fifo_cell15_data_out_do_tri[26] fft_data_in[26]
+ fifo_from_fft_fifo_cell15_sr_out[26] FE_OFN1308_n8079 TBUFX2TS
Xfifo_from_fft_fifo_cell15_data_out_do_tri[25] fft_data_in[25]
+ fifo_from_fft_fifo_cell15_sr_out[25] FE_OFN1306_n8079 TBUFX2TS
Xfifo_from_fft_fifo_cell15_data_out_do_tri[24] fft_data_in[24]
+ fifo_from_fft_fifo_cell15_sr_out[24] FE_OFN1306_n8079 TBUFX2TS
Xfifo_from_fft_fifo_cell15_data_out_do_tri[23] fft_data_in[23]
+ fifo_from_fft_fifo_cell15_sr_out[23] FE_OFN1009_n1545 TBUFX2TS
Xfifo_from_fft_fifo_cell15_data_out_do_tri[22] fft_data_in[22]
+ fifo_from_fft_fifo_cell15_sr_out[22] FE_OFN1013_n1545 TBUFX2TS
Xfifo_from_fft_fifo_cell15_data_out_do_tri[21] fft_data_in[21]
+ fifo_from_fft_fifo_cell15_sr_out[21] FE_OFN1013_n1545 TBUFX2TS
Xfifo_from_fft_fifo_cell15_data_out_do_tri[20] fft_data_in[20]
+ fifo_from_fft_fifo_cell15_sr_out[20] FE_OFN1009_n1545 TBUFX2TS
Xfifo_from_fft_fifo_cell15_data_out_do_tri[19] fft_data_in[19]
+ fifo_from_fft_fifo_cell15_sr_out[19] n1545 TBUFX2TS
Xfifo_from_fft_fifo_cell15_data_out_do_tri[18] fft_data_in[18]
+ fifo_from_fft_fifo_cell15_sr_out[18] FE_OFN1009_n1545 TBUFX2TS
Xfifo_from_fft_fifo_cell15_data_out_do_tri[17] fft_data_in[17]
+ fifo_from_fft_fifo_cell15_sr_out[17] FE_OFN1011_n1545 TBUFX2TS
Xfifo_from_fft_fifo_cell15_data_out_do_tri[16] fft_data_in[16]
+ fifo_from_fft_fifo_cell15_sr_out[16] FE_OFN1011_n1545 TBUFX2TS
Xfifo_from_fft_fifo_cell15_data_out_do_tri[15] fft_data_in[15]
+ fifo_from_fft_fifo_cell15_sr_out[15] FE_OFN1010_n1545 TBUFX2TS
Xfifo_from_fft_fifo_cell15_data_out_do_tri[14] fft_data_in[14]
+ fifo_from_fft_fifo_cell15_sr_out[14] FE_OFN1011_n1545 TBUFX2TS
Xfifo_from_fft_fifo_cell15_data_out_do_tri[13] fft_data_in[13]
+ fifo_from_fft_fifo_cell15_sr_out[13] FE_OFN1010_n1545 TBUFX2TS
Xfifo_from_fft_fifo_cell15_data_out_do_tri[12] fft_data_in[12]
+ fifo_from_fft_fifo_cell15_sr_out[12] FE_OFN1011_n1545 TBUFX2TS
Xfifo_from_fft_fifo_cell15_data_out_do_tri[11] fft_data_in[11]
+ fifo_from_fft_fifo_cell15_sr_out[11] FE_OFN1012_n1545 TBUFX2TS
Xfifo_from_fft_fifo_cell15_data_out_do_tri[10] fft_data_in[10]
+ fifo_from_fft_fifo_cell15_sr_out[10] FE_OFN1013_n1545 TBUFX2TS
Xfifo_from_fft_fifo_cell15_data_out_do_tri[9] fft_data_in[9]
+ fifo_from_fft_fifo_cell15_sr_out[9] FE_OFN1012_n1545 TBUFX2TS
Xfifo_from_fft_fifo_cell15_data_out_do_tri[8] fft_data_in[8]
+ fifo_from_fft_fifo_cell15_sr_out[8] FE_OFN1012_n1545 TBUFX2TS
Xfifo_from_fft_fifo_cell15_data_out_do_tri[7] fft_data_in[7]
+ fifo_from_fft_fifo_cell15_sr_out[7] n8079 TBUFX2TS
Xfifo_from_fft_fifo_cell15_data_out_do_tri[6] fft_data_in[6]
+ fifo_from_fft_fifo_cell15_sr_out[6] n8079 TBUFX2TS
Xfifo_from_fft_fifo_cell15_data_out_do_tri[5] fft_data_in[5]
+ fifo_from_fft_fifo_cell15_sr_out[5] FE_OFN1307_n8079 TBUFX2TS
Xfifo_from_fft_fifo_cell15_data_out_do_tri[4] fft_data_in[4]
+ fifo_from_fft_fifo_cell15_sr_out[4] n8079 TBUFX2TS
Xfifo_from_fft_fifo_cell15_data_out_do_tri[3] fft_data_in[3]
+ fifo_from_fft_fifo_cell15_sr_out[3] FE_OFN1308_n8079 TBUFX2TS
Xfifo_from_fft_fifo_cell15_data_out_do_tri[2] fft_data_in[2]
+ fifo_from_fft_fifo_cell15_sr_out[2] FE_OFN1306_n8079 TBUFX2TS
Xfifo_from_fft_fifo_cell15_data_out_do_tri[1] fft_data_in[1]
+ fifo_from_fft_fifo_cell15_sr_out[1] FE_OFN1307_n8079 TBUFX2TS
Xfifo_from_fft_fifo_cell15_data_out_do_tri[0] fft_data_in[0]
+ fifo_from_fft_fifo_cell15_sr_out[0] FE_OFN1308_n8079 TBUFX2TS
Xfifo_from_fft_fifo_cell14_data_out_do_tri[31] fft_data_in[31]
+ fifo_from_fft_fifo_cell14_sr_out[31] FE_OFN1375_n8078 TBUFX2TS
Xfifo_from_fft_fifo_cell14_data_out_do_tri[30] fft_data_in[30]
+ fifo_from_fft_fifo_cell14_sr_out[30] FE_OFN1375_n8078 TBUFX2TS
Xfifo_from_fft_fifo_cell14_data_out_do_tri[29] fft_data_in[29]
+ fifo_from_fft_fifo_cell14_sr_out[29] FE_OFN1375_n8078 TBUFX2TS
Xfifo_from_fft_fifo_cell14_data_out_do_tri[28] fft_data_in[28]
+ fifo_from_fft_fifo_cell14_sr_out[28] FE_OFN1375_n8078 TBUFX2TS
Xfifo_from_fft_fifo_cell14_data_out_do_tri[27] fft_data_in[27]
+ fifo_from_fft_fifo_cell14_sr_out[27] FE_OFN1373_n8078 TBUFX2TS
Xfifo_from_fft_fifo_cell14_data_out_do_tri[26] fft_data_in[26]
+ fifo_from_fft_fifo_cell14_sr_out[26] FE_OFN1373_n8078 TBUFX2TS
Xfifo_from_fft_fifo_cell14_data_out_do_tri[25] fft_data_in[25]
+ fifo_from_fft_fifo_cell14_sr_out[25] n8078 TBUFX2TS
Xfifo_from_fft_fifo_cell14_data_out_do_tri[24] fft_data_in[24]
+ fifo_from_fft_fifo_cell14_sr_out[24] n8078 TBUFX2TS
Xfifo_from_fft_fifo_cell14_data_out_do_tri[23] fft_data_in[23]
+ fifo_from_fft_fifo_cell14_sr_out[23] FE_OFN1073_n1481 TBUFX2TS
Xfifo_from_fft_fifo_cell14_data_out_do_tri[22] fft_data_in[22]
+ fifo_from_fft_fifo_cell14_sr_out[22] FE_OFN1076_n1481 TBUFX2TS
Xfifo_from_fft_fifo_cell14_data_out_do_tri[21] fft_data_in[21]
+ fifo_from_fft_fifo_cell14_sr_out[21] FE_OFN1076_n1481 TBUFX2TS
Xfifo_from_fft_fifo_cell14_data_out_do_tri[20] fft_data_in[20]
+ fifo_from_fft_fifo_cell14_sr_out[20] FE_OFN1073_n1481 TBUFX2TS
Xfifo_from_fft_fifo_cell14_data_out_do_tri[19] fft_data_in[19]
+ fifo_from_fft_fifo_cell14_sr_out[19] n1481 TBUFX2TS
Xfifo_from_fft_fifo_cell14_data_out_do_tri[18] fft_data_in[18]
+ fifo_from_fft_fifo_cell14_sr_out[18] FE_OFN1073_n1481 TBUFX2TS
Xfifo_from_fft_fifo_cell14_data_out_do_tri[17] fft_data_in[17]
+ fifo_from_fft_fifo_cell14_sr_out[17] n1481 TBUFX2TS
Xfifo_from_fft_fifo_cell14_data_out_do_tri[16] fft_data_in[16]
+ fifo_from_fft_fifo_cell14_sr_out[16] n1481 TBUFX2TS
Xfifo_from_fft_fifo_cell14_data_out_do_tri[15] fft_data_in[15]
+ fifo_from_fft_fifo_cell14_sr_out[15] FE_OFN1074_n1481 TBUFX2TS
Xfifo_from_fft_fifo_cell14_data_out_do_tri[14] fft_data_in[14]
+ fifo_from_fft_fifo_cell14_sr_out[14] FE_OFN1074_n1481 TBUFX2TS
Xfifo_from_fft_fifo_cell14_data_out_do_tri[13] fft_data_in[13]
+ fifo_from_fft_fifo_cell14_sr_out[13] FE_OFN1075_n1481 TBUFX2TS
Xfifo_from_fft_fifo_cell14_data_out_do_tri[12] fft_data_in[12]
+ fifo_from_fft_fifo_cell14_sr_out[12] FE_OFN1074_n1481 TBUFX2TS
Xfifo_from_fft_fifo_cell14_data_out_do_tri[11] fft_data_in[11]
+ fifo_from_fft_fifo_cell14_sr_out[11] FE_OFN1075_n1481 TBUFX2TS
Xfifo_from_fft_fifo_cell14_data_out_do_tri[10] fft_data_in[10]
+ fifo_from_fft_fifo_cell14_sr_out[10] FE_OFN1076_n1481 TBUFX2TS
Xfifo_from_fft_fifo_cell14_data_out_do_tri[9] fft_data_in[9]
+ fifo_from_fft_fifo_cell14_sr_out[9] FE_OFN1076_n1481 TBUFX2TS
Xfifo_from_fft_fifo_cell14_data_out_do_tri[8] fft_data_in[8]
+ fifo_from_fft_fifo_cell14_sr_out[8] FE_OFN1075_n1481 TBUFX2TS
Xfifo_from_fft_fifo_cell14_data_out_do_tri[7] fft_data_in[7]
+ fifo_from_fft_fifo_cell14_sr_out[7] FE_OFN1372_n8078 TBUFX2TS
Xfifo_from_fft_fifo_cell14_data_out_do_tri[6] fft_data_in[6]
+ fifo_from_fft_fifo_cell14_sr_out[6] FE_OFN1371_n8078 TBUFX2TS
Xfifo_from_fft_fifo_cell14_data_out_do_tri[5] fft_data_in[5]
+ fifo_from_fft_fifo_cell14_sr_out[5] FE_OFN1373_n8078 TBUFX2TS
Xfifo_from_fft_fifo_cell14_data_out_do_tri[4] fft_data_in[4]
+ fifo_from_fft_fifo_cell14_sr_out[4] FE_OFN1371_n8078 TBUFX2TS
Xfifo_from_fft_fifo_cell14_data_out_do_tri[3] fft_data_in[3]
+ fifo_from_fft_fifo_cell14_sr_out[3] FE_OFN1374_n8078 TBUFX2TS
Xfifo_from_fft_fifo_cell14_data_out_do_tri[2] fft_data_in[2]
+ fifo_from_fft_fifo_cell14_sr_out[2] FE_OFN1372_n8078 TBUFX2TS
Xfifo_from_fft_fifo_cell14_data_out_do_tri[1] fft_data_in[1]
+ fifo_from_fft_fifo_cell14_sr_out[1] FE_OFN1372_n8078 TBUFX2TS
Xfifo_from_fft_fifo_cell14_data_out_do_tri[0] fft_data_in[0]
+ fifo_from_fft_fifo_cell14_sr_out[0] FE_OFN1374_n8078 TBUFX2TS
Xfifo_from_fft_fifo_cell13_data_out_do_tri[31] fft_data_in[31]
+ fifo_from_fft_fifo_cell13_sr_out[31] FE_OFN1368_n8077 TBUFX2TS
Xfifo_from_fft_fifo_cell13_data_out_do_tri[30] fft_data_in[30]
+ fifo_from_fft_fifo_cell13_sr_out[30] FE_OFN1367_n8077 TBUFX2TS
Xfifo_from_fft_fifo_cell13_data_out_do_tri[29] fft_data_in[29]
+ fifo_from_fft_fifo_cell13_sr_out[29] FE_OFN1368_n8077 TBUFX2TS
Xfifo_from_fft_fifo_cell13_data_out_do_tri[28] fft_data_in[28]
+ fifo_from_fft_fifo_cell13_sr_out[28] FE_OFN1368_n8077 TBUFX2TS
Xfifo_from_fft_fifo_cell13_data_out_do_tri[27] fft_data_in[27]
+ fifo_from_fft_fifo_cell13_sr_out[27] FE_OFN1369_n8077 TBUFX2TS
Xfifo_from_fft_fifo_cell13_data_out_do_tri[26] fft_data_in[26]
+ fifo_from_fft_fifo_cell13_sr_out[26] FE_OFN1369_n8077 TBUFX2TS
Xfifo_from_fft_fifo_cell13_data_out_do_tri[25] fft_data_in[25]
+ fifo_from_fft_fifo_cell13_sr_out[25] FE_OFN1370_n8077 TBUFX2TS
Xfifo_from_fft_fifo_cell13_data_out_do_tri[24] fft_data_in[24]
+ fifo_from_fft_fifo_cell13_sr_out[24] FE_OFN1370_n8077 TBUFX2TS
Xfifo_from_fft_fifo_cell13_data_out_do_tri[23] fft_data_in[23]
+ fifo_from_fft_fifo_cell13_sr_out[23] FE_OFN1072_n1417 TBUFX2TS
Xfifo_from_fft_fifo_cell13_data_out_do_tri[22] fft_data_in[22]
+ fifo_from_fft_fifo_cell13_sr_out[22] FE_OFN1072_n1417 TBUFX2TS
Xfifo_from_fft_fifo_cell13_data_out_do_tri[21] fft_data_in[21]
+ fifo_from_fft_fifo_cell13_sr_out[21] FE_OFN1072_n1417 TBUFX2TS
Xfifo_from_fft_fifo_cell13_data_out_do_tri[20] fft_data_in[20]
+ fifo_from_fft_fifo_cell13_sr_out[20] FE_OFN1072_n1417 TBUFX2TS
Xfifo_from_fft_fifo_cell13_data_out_do_tri[19] fft_data_in[19]
+ fifo_from_fft_fifo_cell13_sr_out[19] n1417 TBUFX2TS
Xfifo_from_fft_fifo_cell13_data_out_do_tri[18] fft_data_in[18]
+ fifo_from_fft_fifo_cell13_sr_out[18] FE_OFN1069_n1417 TBUFX2TS
Xfifo_from_fft_fifo_cell13_data_out_do_tri[17] fft_data_in[17]
+ fifo_from_fft_fifo_cell13_sr_out[17] n1417 TBUFX2TS
Xfifo_from_fft_fifo_cell13_data_out_do_tri[16] fft_data_in[16]
+ fifo_from_fft_fifo_cell13_sr_out[16] n1417 TBUFX2TS
Xfifo_from_fft_fifo_cell13_data_out_do_tri[15] fft_data_in[15]
+ fifo_from_fft_fifo_cell13_sr_out[15] FE_OFN1070_n1417 TBUFX2TS
Xfifo_from_fft_fifo_cell13_data_out_do_tri[14] fft_data_in[14]
+ fifo_from_fft_fifo_cell13_sr_out[14] FE_OFN1069_n1417 TBUFX2TS
Xfifo_from_fft_fifo_cell13_data_out_do_tri[13] fft_data_in[13]
+ fifo_from_fft_fifo_cell13_sr_out[13] FE_OFN1070_n1417 TBUFX2TS
Xfifo_from_fft_fifo_cell13_data_out_do_tri[12] fft_data_in[12]
+ fifo_from_fft_fifo_cell13_sr_out[12] FE_OFN1069_n1417 TBUFX2TS
Xfifo_from_fft_fifo_cell13_data_out_do_tri[11] fft_data_in[11]
+ fifo_from_fft_fifo_cell13_sr_out[11] FE_OFN1070_n1417 TBUFX2TS
Xfifo_from_fft_fifo_cell13_data_out_do_tri[10] fft_data_in[10]
+ fifo_from_fft_fifo_cell13_sr_out[10] FE_OFN1071_n1417 TBUFX2TS
Xfifo_from_fft_fifo_cell13_data_out_do_tri[9] fft_data_in[9]
+ fifo_from_fft_fifo_cell13_sr_out[9] FE_OFN1071_n1417 TBUFX2TS
Xfifo_from_fft_fifo_cell13_data_out_do_tri[8] fft_data_in[8]
+ fifo_from_fft_fifo_cell13_sr_out[8] FE_OFN1071_n1417 TBUFX2TS
Xfifo_from_fft_fifo_cell13_data_out_do_tri[7] fft_data_in[7]
+ fifo_from_fft_fifo_cell13_sr_out[7] FE_OFN1366_n8077 TBUFX2TS
Xfifo_from_fft_fifo_cell13_data_out_do_tri[6] fft_data_in[6]
+ fifo_from_fft_fifo_cell13_sr_out[6] FE_OFN1366_n8077 TBUFX2TS
Xfifo_from_fft_fifo_cell13_data_out_do_tri[5] fft_data_in[5]
+ fifo_from_fft_fifo_cell13_sr_out[5] FE_OFN1366_n8077 TBUFX2TS
Xfifo_from_fft_fifo_cell13_data_out_do_tri[4] fft_data_in[4]
+ fifo_from_fft_fifo_cell13_sr_out[4] n8077 TBUFX2TS
Xfifo_from_fft_fifo_cell13_data_out_do_tri[3] fft_data_in[3]
+ fifo_from_fft_fifo_cell13_sr_out[3] FE_OFN1369_n8077 TBUFX2TS
Xfifo_from_fft_fifo_cell13_data_out_do_tri[2] fft_data_in[2]
+ fifo_from_fft_fifo_cell13_sr_out[2] FE_OFN1370_n8077 TBUFX2TS
Xfifo_from_fft_fifo_cell13_data_out_do_tri[1] fft_data_in[1]
+ fifo_from_fft_fifo_cell13_sr_out[1] FE_OFN1370_n8077 TBUFX2TS
Xfifo_from_fft_fifo_cell13_data_out_do_tri[0] fft_data_in[0]
+ fifo_from_fft_fifo_cell13_sr_out[0] FE_OFN1367_n8077 TBUFX2TS
Xfifo_from_fft_fifo_cell12_data_out_do_tri[31] fft_data_in[31]
+ fifo_from_fft_fifo_cell12_sr_out[31] FE_OFN1365_n8076 TBUFX2TS
Xfifo_from_fft_fifo_cell12_data_out_do_tri[30] fft_data_in[30]
+ fifo_from_fft_fifo_cell12_sr_out[30] FE_OFN1365_n8076 TBUFX2TS
Xfifo_from_fft_fifo_cell12_data_out_do_tri[29] fft_data_in[29]
+ fifo_from_fft_fifo_cell12_sr_out[29] FE_OFN1365_n8076 TBUFX2TS
Xfifo_from_fft_fifo_cell12_data_out_do_tri[28] fft_data_in[28]
+ fifo_from_fft_fifo_cell12_sr_out[28] FE_OFN1365_n8076 TBUFX2TS
Xfifo_from_fft_fifo_cell12_data_out_do_tri[27] fft_data_in[27]
+ fifo_from_fft_fifo_cell12_sr_out[27] FE_OFN1363_n8076 TBUFX2TS
Xfifo_from_fft_fifo_cell12_data_out_do_tri[26] fft_data_in[26]
+ fifo_from_fft_fifo_cell12_sr_out[26] FE_OFN1364_n8076 TBUFX2TS
Xfifo_from_fft_fifo_cell12_data_out_do_tri[25] fft_data_in[25]
+ fifo_from_fft_fifo_cell12_sr_out[25] n8076 TBUFX2TS
Xfifo_from_fft_fifo_cell12_data_out_do_tri[24] fft_data_in[24]
+ fifo_from_fft_fifo_cell12_sr_out[24] n8076 TBUFX2TS
Xfifo_from_fft_fifo_cell12_data_out_do_tri[23] fft_data_in[23]
+ fifo_from_fft_fifo_cell12_sr_out[23] FE_OFN1065_n1353 TBUFX2TS
Xfifo_from_fft_fifo_cell12_data_out_do_tri[22] fft_data_in[22]
+ fifo_from_fft_fifo_cell12_sr_out[22] FE_OFN1068_n1353 TBUFX2TS
Xfifo_from_fft_fifo_cell12_data_out_do_tri[21] fft_data_in[21]
+ fifo_from_fft_fifo_cell12_sr_out[21] FE_OFN1068_n1353 TBUFX2TS
Xfifo_from_fft_fifo_cell12_data_out_do_tri[20] fft_data_in[20]
+ fifo_from_fft_fifo_cell12_sr_out[20] FE_OFN1065_n1353 TBUFX2TS
Xfifo_from_fft_fifo_cell12_data_out_do_tri[19] fft_data_in[19]
+ fifo_from_fft_fifo_cell12_sr_out[19] FE_OFN1065_n1353 TBUFX2TS
Xfifo_from_fft_fifo_cell12_data_out_do_tri[18] fft_data_in[18]
+ fifo_from_fft_fifo_cell12_sr_out[18] FE_OFN1065_n1353 TBUFX2TS
Xfifo_from_fft_fifo_cell12_data_out_do_tri[17] fft_data_in[17]
+ fifo_from_fft_fifo_cell12_sr_out[17] n1353 TBUFX2TS
Xfifo_from_fft_fifo_cell12_data_out_do_tri[16] fft_data_in[16]
+ fifo_from_fft_fifo_cell12_sr_out[16] n1353 TBUFX2TS
Xfifo_from_fft_fifo_cell12_data_out_do_tri[15] fft_data_in[15]
+ fifo_from_fft_fifo_cell12_sr_out[15] FE_OFN1066_n1353 TBUFX2TS
Xfifo_from_fft_fifo_cell12_data_out_do_tri[14] fft_data_in[14]
+ fifo_from_fft_fifo_cell12_sr_out[14] FE_OFN1066_n1353 TBUFX2TS
Xfifo_from_fft_fifo_cell12_data_out_do_tri[13] fft_data_in[13]
+ fifo_from_fft_fifo_cell12_sr_out[13] FE_OFN1067_n1353 TBUFX2TS
Xfifo_from_fft_fifo_cell12_data_out_do_tri[12] fft_data_in[12]
+ fifo_from_fft_fifo_cell12_sr_out[12] FE_OFN1066_n1353 TBUFX2TS
Xfifo_from_fft_fifo_cell12_data_out_do_tri[11] fft_data_in[11]
+ fifo_from_fft_fifo_cell12_sr_out[11] FE_OFN1068_n1353 TBUFX2TS
Xfifo_from_fft_fifo_cell12_data_out_do_tri[10] fft_data_in[10]
+ fifo_from_fft_fifo_cell12_sr_out[10] FE_OFN1068_n1353 TBUFX2TS
Xfifo_from_fft_fifo_cell12_data_out_do_tri[9] fft_data_in[9]
+ fifo_from_fft_fifo_cell12_sr_out[9] FE_OFN1067_n1353 TBUFX2TS
Xfifo_from_fft_fifo_cell12_data_out_do_tri[8] fft_data_in[8]
+ fifo_from_fft_fifo_cell12_sr_out[8] FE_OFN1067_n1353 TBUFX2TS
Xfifo_from_fft_fifo_cell12_data_out_do_tri[7] fft_data_in[7]
+ fifo_from_fft_fifo_cell12_sr_out[7] FE_OFN1362_n8076 TBUFX2TS
Xfifo_from_fft_fifo_cell12_data_out_do_tri[6] fft_data_in[6]
+ fifo_from_fft_fifo_cell12_sr_out[6] FE_OFN1362_n8076 TBUFX2TS
Xfifo_from_fft_fifo_cell12_data_out_do_tri[5] fft_data_in[5]
+ fifo_from_fft_fifo_cell12_sr_out[5] FE_OFN1362_n8076 TBUFX2TS
Xfifo_from_fft_fifo_cell12_data_out_do_tri[4] fft_data_in[4]
+ fifo_from_fft_fifo_cell12_sr_out[4] n8076 TBUFX2TS
Xfifo_from_fft_fifo_cell12_data_out_do_tri[3] fft_data_in[3]
+ fifo_from_fft_fifo_cell12_sr_out[3] FE_OFN1364_n8076 TBUFX2TS
Xfifo_from_fft_fifo_cell12_data_out_do_tri[2] fft_data_in[2]
+ fifo_from_fft_fifo_cell12_sr_out[2] FE_OFN1363_n8076 TBUFX2TS
Xfifo_from_fft_fifo_cell12_data_out_do_tri[1] fft_data_in[1]
+ fifo_from_fft_fifo_cell12_sr_out[1] FE_OFN1363_n8076 TBUFX2TS
Xfifo_from_fft_fifo_cell12_data_out_do_tri[0] fft_data_in[0]
+ fifo_from_fft_fifo_cell12_sr_out[0] FE_OFN1364_n8076 TBUFX2TS
Xfifo_from_fft_fifo_cell11_data_out_do_tri[31] fft_data_in[31]
+ fifo_from_fft_fifo_cell11_sr_out[31] FE_OFN1361_n8075 TBUFX2TS
Xfifo_from_fft_fifo_cell11_data_out_do_tri[30] fft_data_in[30]
+ fifo_from_fft_fifo_cell11_sr_out[30] FE_OFN1361_n8075 TBUFX2TS
Xfifo_from_fft_fifo_cell11_data_out_do_tri[29] fft_data_in[29]
+ fifo_from_fft_fifo_cell11_sr_out[29] FE_OFN1361_n8075 TBUFX2TS
Xfifo_from_fft_fifo_cell11_data_out_do_tri[28] fft_data_in[28]
+ fifo_from_fft_fifo_cell11_sr_out[28] FE_OFN1361_n8075 TBUFX2TS
Xfifo_from_fft_fifo_cell11_data_out_do_tri[27] fft_data_in[27]
+ fifo_from_fft_fifo_cell11_sr_out[27] FE_OFN1358_n8075 TBUFX2TS
Xfifo_from_fft_fifo_cell11_data_out_do_tri[26] fft_data_in[26]
+ fifo_from_fft_fifo_cell11_sr_out[26] FE_OFN1360_n8075 TBUFX2TS
Xfifo_from_fft_fifo_cell11_data_out_do_tri[25] fft_data_in[25]
+ fifo_from_fft_fifo_cell11_sr_out[25] FE_OFN1359_n8075 TBUFX2TS
Xfifo_from_fft_fifo_cell11_data_out_do_tri[24] fft_data_in[24]
+ fifo_from_fft_fifo_cell11_sr_out[24] FE_OFN1359_n8075 TBUFX2TS
Xfifo_from_fft_fifo_cell11_data_out_do_tri[23] fft_data_in[23]
+ fifo_from_fft_fifo_cell11_sr_out[23] FE_OFN1061_n1289 TBUFX2TS
Xfifo_from_fft_fifo_cell11_data_out_do_tri[22] fft_data_in[22]
+ fifo_from_fft_fifo_cell11_sr_out[22] FE_OFN1064_n1289 TBUFX2TS
Xfifo_from_fft_fifo_cell11_data_out_do_tri[21] fft_data_in[21]
+ fifo_from_fft_fifo_cell11_sr_out[21] FE_OFN1064_n1289 TBUFX2TS
Xfifo_from_fft_fifo_cell11_data_out_do_tri[20] fft_data_in[20]
+ fifo_from_fft_fifo_cell11_sr_out[20] FE_OFN1061_n1289 TBUFX2TS
Xfifo_from_fft_fifo_cell11_data_out_do_tri[19] fft_data_in[19]
+ fifo_from_fft_fifo_cell11_sr_out[19] n1289 TBUFX2TS
Xfifo_from_fft_fifo_cell11_data_out_do_tri[18] fft_data_in[18]
+ fifo_from_fft_fifo_cell11_sr_out[18] FE_OFN1061_n1289 TBUFX2TS
Xfifo_from_fft_fifo_cell11_data_out_do_tri[17] fft_data_in[17]
+ fifo_from_fft_fifo_cell11_sr_out[17] n1289 TBUFX2TS
Xfifo_from_fft_fifo_cell11_data_out_do_tri[16] fft_data_in[16]
+ fifo_from_fft_fifo_cell11_sr_out[16] n1289 TBUFX2TS
Xfifo_from_fft_fifo_cell11_data_out_do_tri[15] fft_data_in[15]
+ fifo_from_fft_fifo_cell11_sr_out[15] FE_OFN1062_n1289 TBUFX2TS
Xfifo_from_fft_fifo_cell11_data_out_do_tri[14] fft_data_in[14]
+ fifo_from_fft_fifo_cell11_sr_out[14] FE_OFN1062_n1289 TBUFX2TS
Xfifo_from_fft_fifo_cell11_data_out_do_tri[13] fft_data_in[13]
+ fifo_from_fft_fifo_cell11_sr_out[13] FE_OFN1063_n1289 TBUFX2TS
Xfifo_from_fft_fifo_cell11_data_out_do_tri[12] fft_data_in[12]
+ fifo_from_fft_fifo_cell11_sr_out[12] FE_OFN1062_n1289 TBUFX2TS
Xfifo_from_fft_fifo_cell11_data_out_do_tri[11] fft_data_in[11]
+ fifo_from_fft_fifo_cell11_sr_out[11] FE_OFN1064_n1289 TBUFX2TS
Xfifo_from_fft_fifo_cell11_data_out_do_tri[10] fft_data_in[10]
+ fifo_from_fft_fifo_cell11_sr_out[10] FE_OFN1064_n1289 TBUFX2TS
Xfifo_from_fft_fifo_cell11_data_out_do_tri[9] fft_data_in[9]
+ fifo_from_fft_fifo_cell11_sr_out[9] FE_OFN1063_n1289 TBUFX2TS
Xfifo_from_fft_fifo_cell11_data_out_do_tri[8] fft_data_in[8]
+ fifo_from_fft_fifo_cell11_sr_out[8] FE_OFN1063_n1289 TBUFX2TS
Xfifo_from_fft_fifo_cell11_data_out_do_tri[7] fft_data_in[7]
+ fifo_from_fft_fifo_cell11_sr_out[7] n8075 TBUFX2TS
Xfifo_from_fft_fifo_cell11_data_out_do_tri[6] fft_data_in[6]
+ fifo_from_fft_fifo_cell11_sr_out[6] FE_OFN1357_n8075 TBUFX2TS
Xfifo_from_fft_fifo_cell11_data_out_do_tri[5] fft_data_in[5]
+ fifo_from_fft_fifo_cell11_sr_out[5] FE_OFN1357_n8075 TBUFX2TS
Xfifo_from_fft_fifo_cell11_data_out_do_tri[4] fft_data_in[4]
+ fifo_from_fft_fifo_cell11_sr_out[4] FE_OFN1357_n8075 TBUFX2TS
Xfifo_from_fft_fifo_cell11_data_out_do_tri[3] fft_data_in[3]
+ fifo_from_fft_fifo_cell11_sr_out[3] FE_OFN1360_n8075 TBUFX2TS
Xfifo_from_fft_fifo_cell11_data_out_do_tri[2] fft_data_in[2]
+ fifo_from_fft_fifo_cell11_sr_out[2] FE_OFN1359_n8075 TBUFX2TS
Xfifo_from_fft_fifo_cell11_data_out_do_tri[1] fft_data_in[1]
+ fifo_from_fft_fifo_cell11_sr_out[1] FE_OFN1358_n8075 TBUFX2TS
Xfifo_from_fft_fifo_cell11_data_out_do_tri[0] fft_data_in[0]
+ fifo_from_fft_fifo_cell11_sr_out[0] FE_OFN1360_n8075 TBUFX2TS
Xfifo_from_fft_fifo_cell10_data_out_do_tri[31] fft_data_in[31]
+ fifo_from_fft_fifo_cell10_sr_out[31] FE_OFN1356_n8074 TBUFX2TS
Xfifo_from_fft_fifo_cell10_data_out_do_tri[30] fft_data_in[30]
+ fifo_from_fft_fifo_cell10_sr_out[30] FE_OFN1356_n8074 TBUFX2TS
Xfifo_from_fft_fifo_cell10_data_out_do_tri[29] fft_data_in[29]
+ fifo_from_fft_fifo_cell10_sr_out[29] FE_OFN1356_n8074 TBUFX2TS
Xfifo_from_fft_fifo_cell10_data_out_do_tri[28] fft_data_in[28]
+ fifo_from_fft_fifo_cell10_sr_out[28] FE_OFN1356_n8074 TBUFX2TS
Xfifo_from_fft_fifo_cell10_data_out_do_tri[27] fft_data_in[27]
+ fifo_from_fft_fifo_cell10_sr_out[27] FE_OFN1354_n8074 TBUFX2TS
Xfifo_from_fft_fifo_cell10_data_out_do_tri[26] fft_data_in[26]
+ fifo_from_fft_fifo_cell10_sr_out[26] FE_OFN1355_n8074 TBUFX2TS
Xfifo_from_fft_fifo_cell10_data_out_do_tri[25] fft_data_in[25]
+ fifo_from_fft_fifo_cell10_sr_out[25] FE_OFN1353_n8074 TBUFX2TS
Xfifo_from_fft_fifo_cell10_data_out_do_tri[24] fft_data_in[24]
+ fifo_from_fft_fifo_cell10_sr_out[24] FE_OFN1353_n8074 TBUFX2TS
Xfifo_from_fft_fifo_cell10_data_out_do_tri[23] fft_data_in[23]
+ fifo_from_fft_fifo_cell10_sr_out[23] FE_OFN1058_n1225 TBUFX2TS
Xfifo_from_fft_fifo_cell10_data_out_do_tri[22] fft_data_in[22]
+ fifo_from_fft_fifo_cell10_sr_out[22] FE_OFN1060_n1225 TBUFX2TS
Xfifo_from_fft_fifo_cell10_data_out_do_tri[21] fft_data_in[21]
+ fifo_from_fft_fifo_cell10_sr_out[21] FE_OFN1060_n1225 TBUFX2TS
Xfifo_from_fft_fifo_cell10_data_out_do_tri[20] fft_data_in[20]
+ fifo_from_fft_fifo_cell10_sr_out[20] FE_OFN1057_n1225 TBUFX2TS
Xfifo_from_fft_fifo_cell10_data_out_do_tri[19] fft_data_in[19]
+ fifo_from_fft_fifo_cell10_sr_out[19] FE_OFN1056_n1225 TBUFX2TS
Xfifo_from_fft_fifo_cell10_data_out_do_tri[18] fft_data_in[18]
+ fifo_from_fft_fifo_cell10_sr_out[18] FE_OFN1057_n1225 TBUFX2TS
Xfifo_from_fft_fifo_cell10_data_out_do_tri[17] fft_data_in[17]
+ fifo_from_fft_fifo_cell10_sr_out[17] n1225 TBUFX2TS
Xfifo_from_fft_fifo_cell10_data_out_do_tri[16] fft_data_in[16]
+ fifo_from_fft_fifo_cell10_sr_out[16] FE_OFN1056_n1225 TBUFX2TS
Xfifo_from_fft_fifo_cell10_data_out_do_tri[15] fft_data_in[15]
+ fifo_from_fft_fifo_cell10_sr_out[15] FE_OFN1058_n1225 TBUFX2TS
Xfifo_from_fft_fifo_cell10_data_out_do_tri[14] fft_data_in[14]
+ fifo_from_fft_fifo_cell10_sr_out[14] FE_OFN1057_n1225 TBUFX2TS
Xfifo_from_fft_fifo_cell10_data_out_do_tri[13] fft_data_in[13]
+ fifo_from_fft_fifo_cell10_sr_out[13] FE_OFN1058_n1225 TBUFX2TS
Xfifo_from_fft_fifo_cell10_data_out_do_tri[12] fft_data_in[12]
+ fifo_from_fft_fifo_cell10_sr_out[12] FE_OFN1056_n1225 TBUFX2TS
Xfifo_from_fft_fifo_cell10_data_out_do_tri[11] fft_data_in[11]
+ fifo_from_fft_fifo_cell10_sr_out[11] FE_OFN1059_n1225 TBUFX2TS
Xfifo_from_fft_fifo_cell10_data_out_do_tri[10] fft_data_in[10]
+ fifo_from_fft_fifo_cell10_sr_out[10] FE_OFN1060_n1225 TBUFX2TS
Xfifo_from_fft_fifo_cell10_data_out_do_tri[9] fft_data_in[9]
+ fifo_from_fft_fifo_cell10_sr_out[9] FE_OFN1059_n1225 TBUFX2TS
Xfifo_from_fft_fifo_cell10_data_out_do_tri[8] fft_data_in[8]
+ fifo_from_fft_fifo_cell10_sr_out[8] FE_OFN1059_n1225 TBUFX2TS
Xfifo_from_fft_fifo_cell10_data_out_do_tri[7] fft_data_in[7]
+ fifo_from_fft_fifo_cell10_sr_out[7] FE_OFN1353_n8074 TBUFX2TS
Xfifo_from_fft_fifo_cell10_data_out_do_tri[6] fft_data_in[6]
+ fifo_from_fft_fifo_cell10_sr_out[6] n8074 TBUFX2TS
Xfifo_from_fft_fifo_cell10_data_out_do_tri[5] fft_data_in[5]
+ fifo_from_fft_fifo_cell10_sr_out[5] n8074 TBUFX2TS
Xfifo_from_fft_fifo_cell10_data_out_do_tri[4] fft_data_in[4]
+ fifo_from_fft_fifo_cell10_sr_out[4] n8074 TBUFX2TS
Xfifo_from_fft_fifo_cell10_data_out_do_tri[3] fft_data_in[3]
+ fifo_from_fft_fifo_cell10_sr_out[3] FE_OFN1355_n8074 TBUFX2TS
Xfifo_from_fft_fifo_cell10_data_out_do_tri[2] fft_data_in[2]
+ fifo_from_fft_fifo_cell10_sr_out[2] FE_OFN1354_n8074 TBUFX2TS
Xfifo_from_fft_fifo_cell10_data_out_do_tri[1] fft_data_in[1]
+ fifo_from_fft_fifo_cell10_sr_out[1] FE_OFN1354_n8074 TBUFX2TS
Xfifo_from_fft_fifo_cell10_data_out_do_tri[0] fft_data_in[0]
+ fifo_from_fft_fifo_cell10_sr_out[0] FE_OFN1355_n8074 TBUFX2TS
Xfifo_from_fft_fifo_cell9_data_out_do_tri[31] fft_data_in[31]
+ fifo_from_fft_fifo_cell9_sr_out[31] FE_OFN1352_n8073 TBUFX2TS
Xfifo_from_fft_fifo_cell9_data_out_do_tri[30] fft_data_in[30]
+ fifo_from_fft_fifo_cell9_sr_out[30] FE_OFN1352_n8073 TBUFX2TS
Xfifo_from_fft_fifo_cell9_data_out_do_tri[29] fft_data_in[29]
+ fifo_from_fft_fifo_cell9_sr_out[29] FE_OFN1352_n8073 TBUFX2TS
Xfifo_from_fft_fifo_cell9_data_out_do_tri[28] fft_data_in[28]
+ fifo_from_fft_fifo_cell9_sr_out[28] FE_OFN1352_n8073 TBUFX2TS
Xfifo_from_fft_fifo_cell9_data_out_do_tri[27] fft_data_in[27]
+ fifo_from_fft_fifo_cell9_sr_out[27] FE_OFN1350_n8073 TBUFX2TS
Xfifo_from_fft_fifo_cell9_data_out_do_tri[26] fft_data_in[26]
+ fifo_from_fft_fifo_cell9_sr_out[26] FE_OFN1351_n8073 TBUFX2TS
Xfifo_from_fft_fifo_cell9_data_out_do_tri[25] fft_data_in[25]
+ fifo_from_fft_fifo_cell9_sr_out[25] n8073 TBUFX2TS
Xfifo_from_fft_fifo_cell9_data_out_do_tri[24] fft_data_in[24]
+ fifo_from_fft_fifo_cell9_sr_out[24] n8073 TBUFX2TS
Xfifo_from_fft_fifo_cell9_data_out_do_tri[23] fft_data_in[23]
+ fifo_from_fft_fifo_cell9_sr_out[23] FE_OFN1052_n1161 TBUFX2TS
Xfifo_from_fft_fifo_cell9_data_out_do_tri[22] fft_data_in[22]
+ fifo_from_fft_fifo_cell9_sr_out[22] FE_OFN1053_n1161 TBUFX2TS
Xfifo_from_fft_fifo_cell9_data_out_do_tri[21] fft_data_in[21]
+ fifo_from_fft_fifo_cell9_sr_out[21] FE_OFN1053_n1161 TBUFX2TS
Xfifo_from_fft_fifo_cell9_data_out_do_tri[20] fft_data_in[20]
+ fifo_from_fft_fifo_cell9_sr_out[20] FE_OFN1052_n1161 TBUFX2TS
Xfifo_from_fft_fifo_cell9_data_out_do_tri[19] fft_data_in[19]
+ fifo_from_fft_fifo_cell9_sr_out[19] n1161 TBUFX2TS
Xfifo_from_fft_fifo_cell9_data_out_do_tri[18] fft_data_in[18]
+ fifo_from_fft_fifo_cell9_sr_out[18] n1161 TBUFX2TS
Xfifo_from_fft_fifo_cell9_data_out_do_tri[17] fft_data_in[17]
+ fifo_from_fft_fifo_cell9_sr_out[17] FE_OFN1055_n1161 TBUFX2TS
Xfifo_from_fft_fifo_cell9_data_out_do_tri[16] fft_data_in[16]
+ fifo_from_fft_fifo_cell9_sr_out[16] n1161 TBUFX2TS
Xfifo_from_fft_fifo_cell9_data_out_do_tri[15] fft_data_in[15]
+ fifo_from_fft_fifo_cell9_sr_out[15] FE_OFN1055_n1161 TBUFX2TS
Xfifo_from_fft_fifo_cell9_data_out_do_tri[14] fft_data_in[14]
+ fifo_from_fft_fifo_cell9_sr_out[14] FE_OFN1055_n1161 TBUFX2TS
Xfifo_from_fft_fifo_cell9_data_out_do_tri[13] fft_data_in[13]
+ fifo_from_fft_fifo_cell9_sr_out[13] FE_OFN1054_n1161 TBUFX2TS
Xfifo_from_fft_fifo_cell9_data_out_do_tri[12] fft_data_in[12]
+ fifo_from_fft_fifo_cell9_sr_out[12] FE_OFN1055_n1161 TBUFX2TS
Xfifo_from_fft_fifo_cell9_data_out_do_tri[11] fft_data_in[11]
+ fifo_from_fft_fifo_cell9_sr_out[11] FE_OFN1054_n1161 TBUFX2TS
Xfifo_from_fft_fifo_cell9_data_out_do_tri[10] fft_data_in[10]
+ fifo_from_fft_fifo_cell9_sr_out[10] FE_OFN1052_n1161 TBUFX2TS
Xfifo_from_fft_fifo_cell9_data_out_do_tri[9] fft_data_in[9]
+ fifo_from_fft_fifo_cell9_sr_out[9] FE_OFN1053_n1161 TBUFX2TS
Xfifo_from_fft_fifo_cell9_data_out_do_tri[8] fft_data_in[8]
+ fifo_from_fft_fifo_cell9_sr_out[8] FE_OFN1054_n1161 TBUFX2TS
Xfifo_from_fft_fifo_cell9_data_out_do_tri[7] fft_data_in[7]
+ fifo_from_fft_fifo_cell9_sr_out[7] FE_OFN1349_n8073 TBUFX2TS
Xfifo_from_fft_fifo_cell9_data_out_do_tri[6] fft_data_in[6]
+ fifo_from_fft_fifo_cell9_sr_out[6] FE_OFN1349_n8073 TBUFX2TS
Xfifo_from_fft_fifo_cell9_data_out_do_tri[5] fft_data_in[5]
+ fifo_from_fft_fifo_cell9_sr_out[5] FE_OFN1349_n8073 TBUFX2TS
Xfifo_from_fft_fifo_cell9_data_out_do_tri[4] fft_data_in[4]
+ fifo_from_fft_fifo_cell9_sr_out[4] FE_OFN1349_n8073 TBUFX2TS
Xfifo_from_fft_fifo_cell9_data_out_do_tri[3] fft_data_in[3]
+ fifo_from_fft_fifo_cell9_sr_out[3] FE_OFN1351_n8073 TBUFX2TS
Xfifo_from_fft_fifo_cell9_data_out_do_tri[2] fft_data_in[2]
+ fifo_from_fft_fifo_cell9_sr_out[2] FE_OFN1350_n8073 TBUFX2TS
Xfifo_from_fft_fifo_cell9_data_out_do_tri[1] fft_data_in[1]
+ fifo_from_fft_fifo_cell9_sr_out[1] FE_OFN1350_n8073 TBUFX2TS
Xfifo_from_fft_fifo_cell9_data_out_do_tri[0] fft_data_in[0]
+ fifo_from_fft_fifo_cell9_sr_out[0] FE_OFN1351_n8073 TBUFX2TS
Xfifo_from_fft_fifo_cell8_data_out_do_tri[31] fft_data_in[31]
+ fifo_from_fft_fifo_cell8_sr_out[31] FE_OFN1346_n8072 TBUFX2TS
Xfifo_from_fft_fifo_cell8_data_out_do_tri[30] fft_data_in[30]
+ fifo_from_fft_fifo_cell8_sr_out[30] FE_OFN1345_n8072 TBUFX2TS
Xfifo_from_fft_fifo_cell8_data_out_do_tri[29] fft_data_in[29]
+ fifo_from_fft_fifo_cell8_sr_out[29] FE_OFN1346_n8072 TBUFX2TS
Xfifo_from_fft_fifo_cell8_data_out_do_tri[28] fft_data_in[28]
+ fifo_from_fft_fifo_cell8_sr_out[28] FE_OFN1346_n8072 TBUFX2TS
Xfifo_from_fft_fifo_cell8_data_out_do_tri[27] fft_data_in[27]
+ fifo_from_fft_fifo_cell8_sr_out[27] FE_OFN1347_n8072 TBUFX2TS
Xfifo_from_fft_fifo_cell8_data_out_do_tri[26] fft_data_in[26]
+ fifo_from_fft_fifo_cell8_sr_out[26] FE_OFN1347_n8072 TBUFX2TS
Xfifo_from_fft_fifo_cell8_data_out_do_tri[25] fft_data_in[25]
+ fifo_from_fft_fifo_cell8_sr_out[25] FE_OFN1348_n8072 TBUFX2TS
Xfifo_from_fft_fifo_cell8_data_out_do_tri[24] fft_data_in[24]
+ fifo_from_fft_fifo_cell8_sr_out[24] FE_OFN1348_n8072 TBUFX2TS
Xfifo_from_fft_fifo_cell8_data_out_do_tri[23] fft_data_in[23]
+ fifo_from_fft_fifo_cell8_sr_out[23] FE_OFN1049_n1097 TBUFX2TS
Xfifo_from_fft_fifo_cell8_data_out_do_tri[22] fft_data_in[22]
+ fifo_from_fft_fifo_cell8_sr_out[22] FE_OFN1050_n1097 TBUFX2TS
Xfifo_from_fft_fifo_cell8_data_out_do_tri[21] fft_data_in[21]
+ fifo_from_fft_fifo_cell8_sr_out[21] FE_OFN1050_n1097 TBUFX2TS
Xfifo_from_fft_fifo_cell8_data_out_do_tri[20] fft_data_in[20]
+ fifo_from_fft_fifo_cell8_sr_out[20] FE_OFN1049_n1097 TBUFX2TS
Xfifo_from_fft_fifo_cell8_data_out_do_tri[19] fft_data_in[19]
+ fifo_from_fft_fifo_cell8_sr_out[19] n1097 TBUFX2TS
Xfifo_from_fft_fifo_cell8_data_out_do_tri[18] fft_data_in[18]
+ fifo_from_fft_fifo_cell8_sr_out[18] FE_OFN1049_n1097 TBUFX2TS
Xfifo_from_fft_fifo_cell8_data_out_do_tri[17] fft_data_in[17]
+ fifo_from_fft_fifo_cell8_sr_out[17] n1097 TBUFX2TS
Xfifo_from_fft_fifo_cell8_data_out_do_tri[16] fft_data_in[16]
+ fifo_from_fft_fifo_cell8_sr_out[16] n1097 TBUFX2TS
Xfifo_from_fft_fifo_cell8_data_out_do_tri[15] fft_data_in[15]
+ fifo_from_fft_fifo_cell8_sr_out[15] FE_OFN1048_n1097 TBUFX2TS
Xfifo_from_fft_fifo_cell8_data_out_do_tri[14] fft_data_in[14]
+ fifo_from_fft_fifo_cell8_sr_out[14] FE_OFN1048_n1097 TBUFX2TS
Xfifo_from_fft_fifo_cell8_data_out_do_tri[13] fft_data_in[13]
+ fifo_from_fft_fifo_cell8_sr_out[13] FE_OFN1051_n1097 TBUFX2TS
Xfifo_from_fft_fifo_cell8_data_out_do_tri[12] fft_data_in[12]
+ fifo_from_fft_fifo_cell8_sr_out[12] FE_OFN1048_n1097 TBUFX2TS
Xfifo_from_fft_fifo_cell8_data_out_do_tri[11] fft_data_in[11]
+ fifo_from_fft_fifo_cell8_sr_out[11] FE_OFN1051_n1097 TBUFX2TS
Xfifo_from_fft_fifo_cell8_data_out_do_tri[10] fft_data_in[10]
+ fifo_from_fft_fifo_cell8_sr_out[10] FE_OFN1050_n1097 TBUFX2TS
Xfifo_from_fft_fifo_cell8_data_out_do_tri[9] fft_data_in[9]
+ fifo_from_fft_fifo_cell8_sr_out[9] FE_OFN1051_n1097 TBUFX2TS
Xfifo_from_fft_fifo_cell8_data_out_do_tri[8] fft_data_in[8]
+ fifo_from_fft_fifo_cell8_sr_out[8] FE_OFN1051_n1097 TBUFX2TS
Xfifo_from_fft_fifo_cell8_data_out_do_tri[7] fft_data_in[7]
+ fifo_from_fft_fifo_cell8_sr_out[7] FE_OFN1344_n8072 TBUFX2TS
Xfifo_from_fft_fifo_cell8_data_out_do_tri[6] fft_data_in[6]
+ fifo_from_fft_fifo_cell8_sr_out[6] FE_OFN1344_n8072 TBUFX2TS
Xfifo_from_fft_fifo_cell8_data_out_do_tri[5] fft_data_in[5]
+ fifo_from_fft_fifo_cell8_sr_out[5] FE_OFN1344_n8072 TBUFX2TS
Xfifo_from_fft_fifo_cell8_data_out_do_tri[4] fft_data_in[4]
+ fifo_from_fft_fifo_cell8_sr_out[4] n8072 TBUFX2TS
Xfifo_from_fft_fifo_cell8_data_out_do_tri[3] fft_data_in[3]
+ fifo_from_fft_fifo_cell8_sr_out[3] FE_OFN1347_n8072 TBUFX2TS
Xfifo_from_fft_fifo_cell8_data_out_do_tri[2] fft_data_in[2]
+ fifo_from_fft_fifo_cell8_sr_out[2] FE_OFN1348_n8072 TBUFX2TS
Xfifo_from_fft_fifo_cell8_data_out_do_tri[1] fft_data_in[1]
+ fifo_from_fft_fifo_cell8_sr_out[1] FE_OFN1348_n8072 TBUFX2TS
Xfifo_from_fft_fifo_cell8_data_out_do_tri[0] fft_data_in[0]
+ fifo_from_fft_fifo_cell8_sr_out[0] FE_OFN1345_n8072 TBUFX2TS
Xfifo_from_fft_fifo_cell7_data_out_do_tri[31] fft_data_in[31]
+ fifo_from_fft_fifo_cell7_sr_out[31] FE_OFN1343_n8071 TBUFX2TS
Xfifo_from_fft_fifo_cell7_data_out_do_tri[30] fft_data_in[30]
+ fifo_from_fft_fifo_cell7_sr_out[30] FE_OFN1343_n8071 TBUFX2TS
Xfifo_from_fft_fifo_cell7_data_out_do_tri[29] fft_data_in[29]
+ fifo_from_fft_fifo_cell7_sr_out[29] FE_OFN1343_n8071 TBUFX2TS
Xfifo_from_fft_fifo_cell7_data_out_do_tri[28] fft_data_in[28]
+ fifo_from_fft_fifo_cell7_sr_out[28] FE_OFN1343_n8071 TBUFX2TS
Xfifo_from_fft_fifo_cell7_data_out_do_tri[27] fft_data_in[27]
+ fifo_from_fft_fifo_cell7_sr_out[27] FE_OFN1341_n8071 TBUFX2TS
Xfifo_from_fft_fifo_cell7_data_out_do_tri[26] fft_data_in[26]
+ fifo_from_fft_fifo_cell7_sr_out[26] FE_OFN1342_n8071 TBUFX2TS
Xfifo_from_fft_fifo_cell7_data_out_do_tri[25] fft_data_in[25]
+ fifo_from_fft_fifo_cell7_sr_out[25] FE_OFN1339_n8071 TBUFX2TS
Xfifo_from_fft_fifo_cell7_data_out_do_tri[24] fft_data_in[24]
+ fifo_from_fft_fifo_cell7_sr_out[24] FE_OFN1339_n8071 TBUFX2TS
Xfifo_from_fft_fifo_cell7_data_out_do_tri[23] fft_data_in[23]
+ fifo_from_fft_fifo_cell7_sr_out[23] FE_OFN1045_n1033 TBUFX2TS
Xfifo_from_fft_fifo_cell7_data_out_do_tri[22] fft_data_in[22]
+ fifo_from_fft_fifo_cell7_sr_out[22] FE_OFN1047_n1033 TBUFX2TS
Xfifo_from_fft_fifo_cell7_data_out_do_tri[21] fft_data_in[21]
+ fifo_from_fft_fifo_cell7_sr_out[21] FE_OFN1047_n1033 TBUFX2TS
Xfifo_from_fft_fifo_cell7_data_out_do_tri[20] fft_data_in[20]
+ fifo_from_fft_fifo_cell7_sr_out[20] FE_OFN1045_n1033 TBUFX2TS
Xfifo_from_fft_fifo_cell7_data_out_do_tri[19] fft_data_in[19]
+ fifo_from_fft_fifo_cell7_sr_out[19] n1033 TBUFX2TS
Xfifo_from_fft_fifo_cell7_data_out_do_tri[18] fft_data_in[18]
+ fifo_from_fft_fifo_cell7_sr_out[18] FE_OFN1045_n1033 TBUFX2TS
Xfifo_from_fft_fifo_cell7_data_out_do_tri[17] fft_data_in[17]
+ fifo_from_fft_fifo_cell7_sr_out[17] FE_OFN1043_n1033 TBUFX2TS
Xfifo_from_fft_fifo_cell7_data_out_do_tri[16] fft_data_in[16]
+ fifo_from_fft_fifo_cell7_sr_out[16] FE_OFN1043_n1033 TBUFX2TS
Xfifo_from_fft_fifo_cell7_data_out_do_tri[15] fft_data_in[15]
+ fifo_from_fft_fifo_cell7_sr_out[15] FE_OFN1044_n1033 TBUFX2TS
Xfifo_from_fft_fifo_cell7_data_out_do_tri[14] fft_data_in[14]
+ fifo_from_fft_fifo_cell7_sr_out[14] FE_OFN1044_n1033 TBUFX2TS
Xfifo_from_fft_fifo_cell7_data_out_do_tri[13] fft_data_in[13]
+ fifo_from_fft_fifo_cell7_sr_out[13] FE_OFN1046_n1033 TBUFX2TS
Xfifo_from_fft_fifo_cell7_data_out_do_tri[12] fft_data_in[12]
+ fifo_from_fft_fifo_cell7_sr_out[12] FE_OFN1043_n1033 TBUFX2TS
Xfifo_from_fft_fifo_cell7_data_out_do_tri[11] fft_data_in[11]
+ fifo_from_fft_fifo_cell7_sr_out[11] FE_OFN1046_n1033 TBUFX2TS
Xfifo_from_fft_fifo_cell7_data_out_do_tri[10] fft_data_in[10]
+ fifo_from_fft_fifo_cell7_sr_out[10] FE_OFN1047_n1033 TBUFX2TS
Xfifo_from_fft_fifo_cell7_data_out_do_tri[9] fft_data_in[9]
+ fifo_from_fft_fifo_cell7_sr_out[9] FE_OFN1047_n1033 TBUFX2TS
Xfifo_from_fft_fifo_cell7_data_out_do_tri[8] fft_data_in[8]
+ fifo_from_fft_fifo_cell7_sr_out[8] FE_OFN1046_n1033 TBUFX2TS
Xfifo_from_fft_fifo_cell7_data_out_do_tri[7] fft_data_in[7]
+ fifo_from_fft_fifo_cell7_sr_out[7] FE_OFN1339_n8071 TBUFX2TS
Xfifo_from_fft_fifo_cell7_data_out_do_tri[6] fft_data_in[6]
+ fifo_from_fft_fifo_cell7_sr_out[6] FE_OFN1341_n8071 TBUFX2TS
Xfifo_from_fft_fifo_cell7_data_out_do_tri[5] fft_data_in[5]
+ fifo_from_fft_fifo_cell7_sr_out[5] FE_OFN1341_n8071 TBUFX2TS
Xfifo_from_fft_fifo_cell7_data_out_do_tri[4] fft_data_in[4]
+ fifo_from_fft_fifo_cell7_sr_out[4] n8071 TBUFX2TS
Xfifo_from_fft_fifo_cell7_data_out_do_tri[3] fft_data_in[3]
+ fifo_from_fft_fifo_cell7_sr_out[3] FE_OFN1342_n8071 TBUFX2TS
Xfifo_from_fft_fifo_cell7_data_out_do_tri[2] fft_data_in[2]
+ fifo_from_fft_fifo_cell7_sr_out[2] FE_OFN1340_n8071 TBUFX2TS
Xfifo_from_fft_fifo_cell7_data_out_do_tri[1] fft_data_in[1]
+ fifo_from_fft_fifo_cell7_sr_out[1] FE_OFN1340_n8071 TBUFX2TS
Xfifo_from_fft_fifo_cell7_data_out_do_tri[0] fft_data_in[0]
+ fifo_from_fft_fifo_cell7_sr_out[0] FE_OFN1342_n8071 TBUFX2TS
Xfifo_from_fft_fifo_cell6_data_out_do_tri[31] fft_data_in[31]
+ fifo_from_fft_fifo_cell6_sr_out[31] FE_OFN1338_n8070 TBUFX2TS
Xfifo_from_fft_fifo_cell6_data_out_do_tri[30] fft_data_in[30]
+ fifo_from_fft_fifo_cell6_sr_out[30] FE_OFN1338_n8070 TBUFX2TS
Xfifo_from_fft_fifo_cell6_data_out_do_tri[29] fft_data_in[29]
+ fifo_from_fft_fifo_cell6_sr_out[29] FE_OFN1338_n8070 TBUFX2TS
Xfifo_from_fft_fifo_cell6_data_out_do_tri[28] fft_data_in[28]
+ fifo_from_fft_fifo_cell6_sr_out[28] FE_OFN1338_n8070 TBUFX2TS
Xfifo_from_fft_fifo_cell6_data_out_do_tri[27] fft_data_in[27]
+ fifo_from_fft_fifo_cell6_sr_out[27] FE_OFN1336_n8070 TBUFX2TS
Xfifo_from_fft_fifo_cell6_data_out_do_tri[26] fft_data_in[26]
+ fifo_from_fft_fifo_cell6_sr_out[26] FE_OFN1337_n8070 TBUFX2TS
Xfifo_from_fft_fifo_cell6_data_out_do_tri[25] fft_data_in[25]
+ fifo_from_fft_fifo_cell6_sr_out[25] FE_OFN1335_n8070 TBUFX2TS
Xfifo_from_fft_fifo_cell6_data_out_do_tri[24] fft_data_in[24]
+ fifo_from_fft_fifo_cell6_sr_out[24] FE_OFN1335_n8070 TBUFX2TS
Xfifo_from_fft_fifo_cell6_data_out_do_tri[23] fft_data_in[23]
+ fifo_from_fft_fifo_cell6_sr_out[23] FE_OFN1042_n969 TBUFX2TS
Xfifo_from_fft_fifo_cell6_data_out_do_tri[22] fft_data_in[22]
+ fifo_from_fft_fifo_cell6_sr_out[22] FE_OFN1042_n969 TBUFX2TS
Xfifo_from_fft_fifo_cell6_data_out_do_tri[21] fft_data_in[21]
+ fifo_from_fft_fifo_cell6_sr_out[21] FE_OFN1042_n969 TBUFX2TS
Xfifo_from_fft_fifo_cell6_data_out_do_tri[20] fft_data_in[20]
+ fifo_from_fft_fifo_cell6_sr_out[20] FE_OFN1042_n969 TBUFX2TS
Xfifo_from_fft_fifo_cell6_data_out_do_tri[19] fft_data_in[19]
+ fifo_from_fft_fifo_cell6_sr_out[19] n969 TBUFX2TS
Xfifo_from_fft_fifo_cell6_data_out_do_tri[18] fft_data_in[18]
+ fifo_from_fft_fifo_cell6_sr_out[18] n969 TBUFX2TS
Xfifo_from_fft_fifo_cell6_data_out_do_tri[17] fft_data_in[17]
+ fifo_from_fft_fifo_cell6_sr_out[17] FE_OFN1039_n969 TBUFX2TS
Xfifo_from_fft_fifo_cell6_data_out_do_tri[16] fft_data_in[16]
+ fifo_from_fft_fifo_cell6_sr_out[16] n969 TBUFX2TS
Xfifo_from_fft_fifo_cell6_data_out_do_tri[15] fft_data_in[15]
+ fifo_from_fft_fifo_cell6_sr_out[15] FE_OFN1040_n969 TBUFX2TS
Xfifo_from_fft_fifo_cell6_data_out_do_tri[14] fft_data_in[14]
+ fifo_from_fft_fifo_cell6_sr_out[14] FE_OFN1039_n969 TBUFX2TS
Xfifo_from_fft_fifo_cell6_data_out_do_tri[13] fft_data_in[13]
+ fifo_from_fft_fifo_cell6_sr_out[13] FE_OFN1040_n969 TBUFX2TS
Xfifo_from_fft_fifo_cell6_data_out_do_tri[12] fft_data_in[12]
+ fifo_from_fft_fifo_cell6_sr_out[12] FE_OFN1039_n969 TBUFX2TS
Xfifo_from_fft_fifo_cell6_data_out_do_tri[11] fft_data_in[11]
+ fifo_from_fft_fifo_cell6_sr_out[11] FE_OFN1040_n969 TBUFX2TS
Xfifo_from_fft_fifo_cell6_data_out_do_tri[10] fft_data_in[10]
+ fifo_from_fft_fifo_cell6_sr_out[10] FE_OFN1041_n969 TBUFX2TS
Xfifo_from_fft_fifo_cell6_data_out_do_tri[9] fft_data_in[9]
+ fifo_from_fft_fifo_cell6_sr_out[9] FE_OFN1041_n969 TBUFX2TS
Xfifo_from_fft_fifo_cell6_data_out_do_tri[8] fft_data_in[8]
+ fifo_from_fft_fifo_cell6_sr_out[8] FE_OFN1041_n969 TBUFX2TS
Xfifo_from_fft_fifo_cell6_data_out_do_tri[7] fft_data_in[7]
+ fifo_from_fft_fifo_cell6_sr_out[7] FE_OFN1335_n8070 TBUFX2TS
Xfifo_from_fft_fifo_cell6_data_out_do_tri[6] fft_data_in[6]
+ fifo_from_fft_fifo_cell6_sr_out[6] n8070 TBUFX2TS
Xfifo_from_fft_fifo_cell6_data_out_do_tri[5] fft_data_in[5]
+ fifo_from_fft_fifo_cell6_sr_out[5] n8070 TBUFX2TS
Xfifo_from_fft_fifo_cell6_data_out_do_tri[4] fft_data_in[4]
+ fifo_from_fft_fifo_cell6_sr_out[4] n8070 TBUFX2TS
Xfifo_from_fft_fifo_cell6_data_out_do_tri[3] fft_data_in[3]
+ fifo_from_fft_fifo_cell6_sr_out[3] FE_OFN1337_n8070 TBUFX2TS
Xfifo_from_fft_fifo_cell6_data_out_do_tri[2] fft_data_in[2]
+ fifo_from_fft_fifo_cell6_sr_out[2] FE_OFN1336_n8070 TBUFX2TS
Xfifo_from_fft_fifo_cell6_data_out_do_tri[1] fft_data_in[1]
+ fifo_from_fft_fifo_cell6_sr_out[1] FE_OFN1336_n8070 TBUFX2TS
Xfifo_from_fft_fifo_cell6_data_out_do_tri[0] fft_data_in[0]
+ fifo_from_fft_fifo_cell6_sr_out[0] FE_OFN1337_n8070 TBUFX2TS
Xfifo_from_fft_fifo_cell5_data_out_do_tri[31] fft_data_in[31]
+ fifo_from_fft_fifo_cell5_sr_out[31] FE_OFN1331_n8069 TBUFX2TS
Xfifo_from_fft_fifo_cell5_data_out_do_tri[30] fft_data_in[30]
+ fifo_from_fft_fifo_cell5_sr_out[30] FE_OFN1332_n8069 TBUFX2TS
Xfifo_from_fft_fifo_cell5_data_out_do_tri[29] fft_data_in[29]
+ fifo_from_fft_fifo_cell5_sr_out[29] FE_OFN1332_n8069 TBUFX2TS
Xfifo_from_fft_fifo_cell5_data_out_do_tri[28] fft_data_in[28]
+ fifo_from_fft_fifo_cell5_sr_out[28] FE_OFN1331_n8069 TBUFX2TS
Xfifo_from_fft_fifo_cell5_data_out_do_tri[27] fft_data_in[27]
+ fifo_from_fft_fifo_cell5_sr_out[27] FE_OFN1333_n8069 TBUFX2TS
Xfifo_from_fft_fifo_cell5_data_out_do_tri[26] fft_data_in[26]
+ fifo_from_fft_fifo_cell5_sr_out[26] FE_OFN1333_n8069 TBUFX2TS
Xfifo_from_fft_fifo_cell5_data_out_do_tri[25] fft_data_in[25]
+ fifo_from_fft_fifo_cell5_sr_out[25] FE_OFN1334_n8069 TBUFX2TS
Xfifo_from_fft_fifo_cell5_data_out_do_tri[24] fft_data_in[24]
+ fifo_from_fft_fifo_cell5_sr_out[24] FE_OFN1334_n8069 TBUFX2TS
Xfifo_from_fft_fifo_cell5_data_out_do_tri[23] fft_data_in[23]
+ fifo_from_fft_fifo_cell5_sr_out[23] FE_OFN1035_n905 TBUFX2TS
Xfifo_from_fft_fifo_cell5_data_out_do_tri[22] fft_data_in[22]
+ fifo_from_fft_fifo_cell5_sr_out[22] FE_OFN1038_n905 TBUFX2TS
Xfifo_from_fft_fifo_cell5_data_out_do_tri[21] fft_data_in[21]
+ fifo_from_fft_fifo_cell5_sr_out[21] FE_OFN1038_n905 TBUFX2TS
Xfifo_from_fft_fifo_cell5_data_out_do_tri[20] fft_data_in[20]
+ fifo_from_fft_fifo_cell5_sr_out[20] FE_OFN1035_n905 TBUFX2TS
Xfifo_from_fft_fifo_cell5_data_out_do_tri[19] fft_data_in[19]
+ fifo_from_fft_fifo_cell5_sr_out[19] n905 TBUFX2TS
Xfifo_from_fft_fifo_cell5_data_out_do_tri[18] fft_data_in[18]
+ fifo_from_fft_fifo_cell5_sr_out[18] n905 TBUFX2TS
Xfifo_from_fft_fifo_cell5_data_out_do_tri[17] fft_data_in[17]
+ fifo_from_fft_fifo_cell5_sr_out[17] FE_OFN1037_n905 TBUFX2TS
Xfifo_from_fft_fifo_cell5_data_out_do_tri[16] fft_data_in[16]
+ fifo_from_fft_fifo_cell5_sr_out[16] FE_OFN1037_n905 TBUFX2TS
Xfifo_from_fft_fifo_cell5_data_out_do_tri[15] fft_data_in[15]
+ fifo_from_fft_fifo_cell5_sr_out[15] FE_OFN1034_n905 TBUFX2TS
Xfifo_from_fft_fifo_cell5_data_out_do_tri[14] fft_data_in[14]
+ fifo_from_fft_fifo_cell5_sr_out[14] FE_OFN1037_n905 TBUFX2TS
Xfifo_from_fft_fifo_cell5_data_out_do_tri[13] fft_data_in[13]
+ fifo_from_fft_fifo_cell5_sr_out[13] FE_OFN1036_n905 TBUFX2TS
Xfifo_from_fft_fifo_cell5_data_out_do_tri[12] fft_data_in[12]
+ fifo_from_fft_fifo_cell5_sr_out[12] FE_OFN1037_n905 TBUFX2TS
Xfifo_from_fft_fifo_cell5_data_out_do_tri[11] fft_data_in[11]
+ fifo_from_fft_fifo_cell5_sr_out[11] FE_OFN1036_n905 TBUFX2TS
Xfifo_from_fft_fifo_cell5_data_out_do_tri[10] fft_data_in[10]
+ fifo_from_fft_fifo_cell5_sr_out[10] FE_OFN1038_n905 TBUFX2TS
Xfifo_from_fft_fifo_cell5_data_out_do_tri[9] fft_data_in[9]
+ fifo_from_fft_fifo_cell5_sr_out[9] FE_OFN1038_n905 TBUFX2TS
Xfifo_from_fft_fifo_cell5_data_out_do_tri[8] fft_data_in[8]
+ fifo_from_fft_fifo_cell5_sr_out[8] FE_OFN1036_n905 TBUFX2TS
Xfifo_from_fft_fifo_cell5_data_out_do_tri[7] fft_data_in[7]
+ fifo_from_fft_fifo_cell5_sr_out[7] n8069 TBUFX2TS
Xfifo_from_fft_fifo_cell5_data_out_do_tri[6] fft_data_in[6]
+ fifo_from_fft_fifo_cell5_sr_out[6] n8069 TBUFX2TS
Xfifo_from_fft_fifo_cell5_data_out_do_tri[5] fft_data_in[5]
+ fifo_from_fft_fifo_cell5_sr_out[5] FE_OFN1331_n8069 TBUFX2TS
Xfifo_from_fft_fifo_cell5_data_out_do_tri[4] fft_data_in[4]
+ fifo_from_fft_fifo_cell5_sr_out[4] n8069 TBUFX2TS
Xfifo_from_fft_fifo_cell5_data_out_do_tri[3] fft_data_in[3]
+ fifo_from_fft_fifo_cell5_sr_out[3] FE_OFN1333_n8069 TBUFX2TS
Xfifo_from_fft_fifo_cell5_data_out_do_tri[2] fft_data_in[2]
+ fifo_from_fft_fifo_cell5_sr_out[2] FE_OFN1334_n8069 TBUFX2TS
Xfifo_from_fft_fifo_cell5_data_out_do_tri[1] fft_data_in[1]
+ fifo_from_fft_fifo_cell5_sr_out[1] FE_OFN1334_n8069 TBUFX2TS
Xfifo_from_fft_fifo_cell5_data_out_do_tri[0] fft_data_in[0]
+ fifo_from_fft_fifo_cell5_sr_out[0] FE_OFN1332_n8069 TBUFX2TS
Xfifo_from_fft_fifo_cell4_data_out_do_tri[31] fft_data_in[31]
+ fifo_from_fft_fifo_cell4_sr_out[31] FE_OFN1330_n8068 TBUFX2TS
Xfifo_from_fft_fifo_cell4_data_out_do_tri[30] fft_data_in[30]
+ fifo_from_fft_fifo_cell4_sr_out[30] FE_OFN1330_n8068 TBUFX2TS
Xfifo_from_fft_fifo_cell4_data_out_do_tri[29] fft_data_in[29]
+ fifo_from_fft_fifo_cell4_sr_out[29] FE_OFN1330_n8068 TBUFX2TS
Xfifo_from_fft_fifo_cell4_data_out_do_tri[28] fft_data_in[28]
+ fifo_from_fft_fifo_cell4_sr_out[28] FE_OFN1330_n8068 TBUFX2TS
Xfifo_from_fft_fifo_cell4_data_out_do_tri[27] fft_data_in[27]
+ fifo_from_fft_fifo_cell4_sr_out[27] FE_OFN1328_n8068 TBUFX2TS
Xfifo_from_fft_fifo_cell4_data_out_do_tri[26] fft_data_in[26]
+ fifo_from_fft_fifo_cell4_sr_out[26] FE_OFN1329_n8068 TBUFX2TS
Xfifo_from_fft_fifo_cell4_data_out_do_tri[25] fft_data_in[25]
+ fifo_from_fft_fifo_cell4_sr_out[25] n8068 TBUFX2TS
Xfifo_from_fft_fifo_cell4_data_out_do_tri[24] fft_data_in[24]
+ fifo_from_fft_fifo_cell4_sr_out[24] FE_OFN1327_n8068 TBUFX2TS
Xfifo_from_fft_fifo_cell4_data_out_do_tri[23] fft_data_in[23]
+ fifo_from_fft_fifo_cell4_sr_out[23] n841 TBUFX2TS
Xfifo_from_fft_fifo_cell4_data_out_do_tri[22] fft_data_in[22]
+ fifo_from_fft_fifo_cell4_sr_out[22] FE_OFN1030_n841 TBUFX2TS
Xfifo_from_fft_fifo_cell4_data_out_do_tri[21] fft_data_in[21]
+ fifo_from_fft_fifo_cell4_sr_out[21] FE_OFN1030_n841 TBUFX2TS
Xfifo_from_fft_fifo_cell4_data_out_do_tri[20] fft_data_in[20]
+ fifo_from_fft_fifo_cell4_sr_out[20] FE_OFN1031_n841 TBUFX2TS
Xfifo_from_fft_fifo_cell4_data_out_do_tri[19] fft_data_in[19]
+ fifo_from_fft_fifo_cell4_sr_out[19] n841 TBUFX2TS
Xfifo_from_fft_fifo_cell4_data_out_do_tri[18] fft_data_in[18]
+ fifo_from_fft_fifo_cell4_sr_out[18] n841 TBUFX2TS
Xfifo_from_fft_fifo_cell4_data_out_do_tri[17] fft_data_in[17]
+ fifo_from_fft_fifo_cell4_sr_out[17] FE_OFN1033_n841 TBUFX2TS
Xfifo_from_fft_fifo_cell4_data_out_do_tri[16] fft_data_in[16]
+ fifo_from_fft_fifo_cell4_sr_out[16] FE_OFN1033_n841 TBUFX2TS
Xfifo_from_fft_fifo_cell4_data_out_do_tri[15] fft_data_in[15]
+ fifo_from_fft_fifo_cell4_sr_out[15] FE_OFN1032_n841 TBUFX2TS
Xfifo_from_fft_fifo_cell4_data_out_do_tri[14] fft_data_in[14]
+ fifo_from_fft_fifo_cell4_sr_out[14] FE_OFN1033_n841 TBUFX2TS
Xfifo_from_fft_fifo_cell4_data_out_do_tri[13] fft_data_in[13]
+ fifo_from_fft_fifo_cell4_sr_out[13] FE_OFN1032_n841 TBUFX2TS
Xfifo_from_fft_fifo_cell4_data_out_do_tri[12] fft_data_in[12]
+ fifo_from_fft_fifo_cell4_sr_out[12] FE_OFN1033_n841 TBUFX2TS
Xfifo_from_fft_fifo_cell4_data_out_do_tri[11] fft_data_in[11]
+ fifo_from_fft_fifo_cell4_sr_out[11] FE_OFN1031_n841 TBUFX2TS
Xfifo_from_fft_fifo_cell4_data_out_do_tri[10] fft_data_in[10]
+ fifo_from_fft_fifo_cell4_sr_out[10] FE_OFN1030_n841 TBUFX2TS
Xfifo_from_fft_fifo_cell4_data_out_do_tri[9] fft_data_in[9]
+ fifo_from_fft_fifo_cell4_sr_out[9] FE_OFN1031_n841 TBUFX2TS
Xfifo_from_fft_fifo_cell4_data_out_do_tri[8] fft_data_in[8]
+ fifo_from_fft_fifo_cell4_sr_out[8] FE_OFN1032_n841 TBUFX2TS
Xfifo_from_fft_fifo_cell4_data_out_do_tri[7] fft_data_in[7]
+ fifo_from_fft_fifo_cell4_sr_out[7] n8068 TBUFX2TS
Xfifo_from_fft_fifo_cell4_data_out_do_tri[6] fft_data_in[6]
+ fifo_from_fft_fifo_cell4_sr_out[6] FE_OFN1328_n8068 TBUFX2TS
Xfifo_from_fft_fifo_cell4_data_out_do_tri[5] fft_data_in[5]
+ fifo_from_fft_fifo_cell4_sr_out[5] FE_OFN1328_n8068 TBUFX2TS
Xfifo_from_fft_fifo_cell4_data_out_do_tri[4] fft_data_in[4]
+ fifo_from_fft_fifo_cell4_sr_out[4] n8068 TBUFX2TS
Xfifo_from_fft_fifo_cell4_data_out_do_tri[3] fft_data_in[3]
+ fifo_from_fft_fifo_cell4_sr_out[3] FE_OFN1329_n8068 TBUFX2TS
Xfifo_from_fft_fifo_cell4_data_out_do_tri[2] fft_data_in[2]
+ fifo_from_fft_fifo_cell4_sr_out[2] FE_OFN1327_n8068 TBUFX2TS
Xfifo_from_fft_fifo_cell4_data_out_do_tri[1] fft_data_in[1]
+ fifo_from_fft_fifo_cell4_sr_out[1] FE_OFN1327_n8068 TBUFX2TS
Xfifo_from_fft_fifo_cell4_data_out_do_tri[0] fft_data_in[0]
+ fifo_from_fft_fifo_cell4_sr_out[0] FE_OFN1329_n8068 TBUFX2TS
Xfifo_from_fft_fifo_cell3_data_out_do_tri[31] fft_data_in[31]
+ fifo_from_fft_fifo_cell3_sr_out[31] FE_OFN1325_n8067 TBUFX2TS
Xfifo_from_fft_fifo_cell3_data_out_do_tri[30] fft_data_in[30]
+ fifo_from_fft_fifo_cell3_sr_out[30] FE_OFN1326_n8067 TBUFX2TS
Xfifo_from_fft_fifo_cell3_data_out_do_tri[29] fft_data_in[29]
+ fifo_from_fft_fifo_cell3_sr_out[29] FE_OFN1325_n8067 TBUFX2TS
Xfifo_from_fft_fifo_cell3_data_out_do_tri[28] fft_data_in[28]
+ fifo_from_fft_fifo_cell3_sr_out[28] FE_OFN1325_n8067 TBUFX2TS
Xfifo_from_fft_fifo_cell3_data_out_do_tri[27] fft_data_in[27]
+ fifo_from_fft_fifo_cell3_sr_out[27] FE_OFN1324_n8067 TBUFX2TS
Xfifo_from_fft_fifo_cell3_data_out_do_tri[26] fft_data_in[26]
+ fifo_from_fft_fifo_cell3_sr_out[26] FE_OFN1326_n8067 TBUFX2TS
Xfifo_from_fft_fifo_cell3_data_out_do_tri[25] fft_data_in[25]
+ fifo_from_fft_fifo_cell3_sr_out[25] FE_OFN1323_n8067 TBUFX2TS
Xfifo_from_fft_fifo_cell3_data_out_do_tri[24] fft_data_in[24]
+ fifo_from_fft_fifo_cell3_sr_out[24] FE_OFN1323_n8067 TBUFX2TS
Xfifo_from_fft_fifo_cell3_data_out_do_tri[23] fft_data_in[23]
+ fifo_from_fft_fifo_cell3_sr_out[23] FE_OFN1027_n777 TBUFX2TS
Xfifo_from_fft_fifo_cell3_data_out_do_tri[22] fft_data_in[22]
+ fifo_from_fft_fifo_cell3_sr_out[22] FE_OFN1029_n777 TBUFX2TS
Xfifo_from_fft_fifo_cell3_data_out_do_tri[21] fft_data_in[21]
+ fifo_from_fft_fifo_cell3_sr_out[21] FE_OFN1029_n777 TBUFX2TS
Xfifo_from_fft_fifo_cell3_data_out_do_tri[20] fft_data_in[20]
+ fifo_from_fft_fifo_cell3_sr_out[20] FE_OFN1029_n777 TBUFX2TS
Xfifo_from_fft_fifo_cell3_data_out_do_tri[19] fft_data_in[19]
+ fifo_from_fft_fifo_cell3_sr_out[19] n777 TBUFX2TS
Xfifo_from_fft_fifo_cell3_data_out_do_tri[18] fft_data_in[18]
+ fifo_from_fft_fifo_cell3_sr_out[18] FE_OFN1027_n777 TBUFX2TS
Xfifo_from_fft_fifo_cell3_data_out_do_tri[17] fft_data_in[17]
+ fifo_from_fft_fifo_cell3_sr_out[17] n777 TBUFX2TS
Xfifo_from_fft_fifo_cell3_data_out_do_tri[16] fft_data_in[16]
+ fifo_from_fft_fifo_cell3_sr_out[16] n777 TBUFX2TS
Xfifo_from_fft_fifo_cell3_data_out_do_tri[15] fft_data_in[15]
+ fifo_from_fft_fifo_cell3_sr_out[15] FE_OFN1026_n777 TBUFX2TS
Xfifo_from_fft_fifo_cell3_data_out_do_tri[14] fft_data_in[14]
+ fifo_from_fft_fifo_cell3_sr_out[14] FE_OFN1026_n777 TBUFX2TS
Xfifo_from_fft_fifo_cell3_data_out_do_tri[13] fft_data_in[13]
+ fifo_from_fft_fifo_cell3_sr_out[13] FE_OFN1028_n777 TBUFX2TS
Xfifo_from_fft_fifo_cell3_data_out_do_tri[12] fft_data_in[12]
+ fifo_from_fft_fifo_cell3_sr_out[12] FE_OFN1026_n777 TBUFX2TS
Xfifo_from_fft_fifo_cell3_data_out_do_tri[11] fft_data_in[11]
+ fifo_from_fft_fifo_cell3_sr_out[11] FE_OFN1028_n777 TBUFX2TS
Xfifo_from_fft_fifo_cell3_data_out_do_tri[10] fft_data_in[10]
+ fifo_from_fft_fifo_cell3_sr_out[10] FE_OFN1029_n777 TBUFX2TS
Xfifo_from_fft_fifo_cell3_data_out_do_tri[9] fft_data_in[9]
+ fifo_from_fft_fifo_cell3_sr_out[9] FE_OFN1028_n777 TBUFX2TS
Xfifo_from_fft_fifo_cell3_data_out_do_tri[8] fft_data_in[8]
+ fifo_from_fft_fifo_cell3_sr_out[8] FE_OFN1028_n777 TBUFX2TS
Xfifo_from_fft_fifo_cell3_data_out_do_tri[7] fft_data_in[7]
+ fifo_from_fft_fifo_cell3_sr_out[7] n8067 TBUFX2TS
Xfifo_from_fft_fifo_cell3_data_out_do_tri[6] fft_data_in[6]
+ fifo_from_fft_fifo_cell3_sr_out[6] n8067 TBUFX2TS
Xfifo_from_fft_fifo_cell3_data_out_do_tri[5] fft_data_in[5]
+ fifo_from_fft_fifo_cell3_sr_out[5] FE_OFN1325_n8067 TBUFX2TS
Xfifo_from_fft_fifo_cell3_data_out_do_tri[4] fft_data_in[4]
+ fifo_from_fft_fifo_cell3_sr_out[4] n8067 TBUFX2TS
Xfifo_from_fft_fifo_cell3_data_out_do_tri[3] fft_data_in[3]
+ fifo_from_fft_fifo_cell3_sr_out[3] FE_OFN1326_n8067 TBUFX2TS
Xfifo_from_fft_fifo_cell3_data_out_do_tri[2] fft_data_in[2]
+ fifo_from_fft_fifo_cell3_sr_out[2] FE_OFN1323_n8067 TBUFX2TS
Xfifo_from_fft_fifo_cell3_data_out_do_tri[1] fft_data_in[1]
+ fifo_from_fft_fifo_cell3_sr_out[1] FE_OFN1324_n8067 TBUFX2TS
Xfifo_from_fft_fifo_cell3_data_out_do_tri[0] fft_data_in[0]
+ fifo_from_fft_fifo_cell3_sr_out[0] FE_OFN1326_n8067 TBUFX2TS
Xfifo_from_fft_fifo_cell2_data_out_do_tri[31] fft_data_in[31]
+ fifo_from_fft_fifo_cell2_sr_out[31] FE_OFN1319_n8066 TBUFX2TS
Xfifo_from_fft_fifo_cell2_data_out_do_tri[30] fft_data_in[30]
+ fifo_from_fft_fifo_cell2_sr_out[30] FE_OFN1320_n8066 TBUFX2TS
Xfifo_from_fft_fifo_cell2_data_out_do_tri[29] fft_data_in[29]
+ fifo_from_fft_fifo_cell2_sr_out[29] FE_OFN1319_n8066 TBUFX2TS
Xfifo_from_fft_fifo_cell2_data_out_do_tri[28] fft_data_in[28]
+ fifo_from_fft_fifo_cell2_sr_out[28] FE_OFN1319_n8066 TBUFX2TS
Xfifo_from_fft_fifo_cell2_data_out_do_tri[27] fft_data_in[27]
+ fifo_from_fft_fifo_cell2_sr_out[27] FE_OFN1321_n8066 TBUFX2TS
Xfifo_from_fft_fifo_cell2_data_out_do_tri[26] fft_data_in[26]
+ fifo_from_fft_fifo_cell2_sr_out[26] FE_OFN1321_n8066 TBUFX2TS
Xfifo_from_fft_fifo_cell2_data_out_do_tri[25] fft_data_in[25]
+ fifo_from_fft_fifo_cell2_sr_out[25] FE_OFN1322_n8066 TBUFX2TS
Xfifo_from_fft_fifo_cell2_data_out_do_tri[24] fft_data_in[24]
+ fifo_from_fft_fifo_cell2_sr_out[24] FE_OFN1322_n8066 TBUFX2TS
Xfifo_from_fft_fifo_cell2_data_out_do_tri[23] fft_data_in[23]
+ fifo_from_fft_fifo_cell2_sr_out[23] FE_OFN1025_n713 TBUFX2TS
Xfifo_from_fft_fifo_cell2_data_out_do_tri[22] fft_data_in[22]
+ fifo_from_fft_fifo_cell2_sr_out[22] FE_OFN1025_n713 TBUFX2TS
Xfifo_from_fft_fifo_cell2_data_out_do_tri[21] fft_data_in[21]
+ fifo_from_fft_fifo_cell2_sr_out[21] FE_OFN1025_n713 TBUFX2TS
Xfifo_from_fft_fifo_cell2_data_out_do_tri[20] fft_data_in[20]
+ fifo_from_fft_fifo_cell2_sr_out[20] FE_OFN1025_n713 TBUFX2TS
Xfifo_from_fft_fifo_cell2_data_out_do_tri[19] fft_data_in[19]
+ fifo_from_fft_fifo_cell2_sr_out[19] n713 TBUFX2TS
Xfifo_from_fft_fifo_cell2_data_out_do_tri[18] fft_data_in[18]
+ fifo_from_fft_fifo_cell2_sr_out[18] FE_OFN1022_n713 TBUFX2TS
Xfifo_from_fft_fifo_cell2_data_out_do_tri[17] fft_data_in[17]
+ fifo_from_fft_fifo_cell2_sr_out[17] n713 TBUFX2TS
Xfifo_from_fft_fifo_cell2_data_out_do_tri[16] fft_data_in[16]
+ fifo_from_fft_fifo_cell2_sr_out[16] n713 TBUFX2TS
Xfifo_from_fft_fifo_cell2_data_out_do_tri[15] fft_data_in[15]
+ fifo_from_fft_fifo_cell2_sr_out[15] FE_OFN1023_n713 TBUFX2TS
Xfifo_from_fft_fifo_cell2_data_out_do_tri[14] fft_data_in[14]
+ fifo_from_fft_fifo_cell2_sr_out[14] FE_OFN1022_n713 TBUFX2TS
Xfifo_from_fft_fifo_cell2_data_out_do_tri[13] fft_data_in[13]
+ fifo_from_fft_fifo_cell2_sr_out[13] FE_OFN1023_n713 TBUFX2TS
Xfifo_from_fft_fifo_cell2_data_out_do_tri[12] fft_data_in[12]
+ fifo_from_fft_fifo_cell2_sr_out[12] FE_OFN1022_n713 TBUFX2TS
Xfifo_from_fft_fifo_cell2_data_out_do_tri[11] fft_data_in[11]
+ fifo_from_fft_fifo_cell2_sr_out[11] FE_OFN1023_n713 TBUFX2TS
Xfifo_from_fft_fifo_cell2_data_out_do_tri[10] fft_data_in[10]
+ fifo_from_fft_fifo_cell2_sr_out[10] FE_OFN1024_n713 TBUFX2TS
Xfifo_from_fft_fifo_cell2_data_out_do_tri[9] fft_data_in[9]
+ fifo_from_fft_fifo_cell2_sr_out[9] FE_OFN1024_n713 TBUFX2TS
Xfifo_from_fft_fifo_cell2_data_out_do_tri[8] fft_data_in[8]
+ fifo_from_fft_fifo_cell2_sr_out[8] FE_OFN1024_n713 TBUFX2TS
Xfifo_from_fft_fifo_cell2_data_out_do_tri[7] fft_data_in[7]
+ fifo_from_fft_fifo_cell2_sr_out[7] FE_OFN1318_n8066 TBUFX2TS
Xfifo_from_fft_fifo_cell2_data_out_do_tri[6] fft_data_in[6]
+ fifo_from_fft_fifo_cell2_sr_out[6] FE_OFN1318_n8066 TBUFX2TS
Xfifo_from_fft_fifo_cell2_data_out_do_tri[5] fft_data_in[5]
+ fifo_from_fft_fifo_cell2_sr_out[5] FE_OFN1318_n8066 TBUFX2TS
Xfifo_from_fft_fifo_cell2_data_out_do_tri[4] fft_data_in[4]
+ fifo_from_fft_fifo_cell2_sr_out[4] n8066 TBUFX2TS
Xfifo_from_fft_fifo_cell2_data_out_do_tri[3] fft_data_in[3]
+ fifo_from_fft_fifo_cell2_sr_out[3] FE_OFN1320_n8066 TBUFX2TS
Xfifo_from_fft_fifo_cell2_data_out_do_tri[2] fft_data_in[2]
+ fifo_from_fft_fifo_cell2_sr_out[2] FE_OFN1322_n8066 TBUFX2TS
Xfifo_from_fft_fifo_cell2_data_out_do_tri[1] fft_data_in[1]
+ fifo_from_fft_fifo_cell2_sr_out[1] FE_OFN1322_n8066 TBUFX2TS
Xfifo_from_fft_fifo_cell2_data_out_do_tri[0] fft_data_in[0]
+ fifo_from_fft_fifo_cell2_sr_out[0] FE_OFN1320_n8066 TBUFX2TS
Xfifo_from_fft_fifo_cell1_data_out_do_tri[31] fft_data_in[31]
+ fifo_from_fft_fifo_cell1_sr_out[31] FE_OFN1317_n8065 TBUFX2TS
Xfifo_from_fft_fifo_cell1_data_out_do_tri[30] fft_data_in[30]
+ fifo_from_fft_fifo_cell1_sr_out[30] FE_OFN1317_n8065 TBUFX2TS
Xfifo_from_fft_fifo_cell1_data_out_do_tri[29] fft_data_in[29]
+ fifo_from_fft_fifo_cell1_sr_out[29] FE_OFN1317_n8065 TBUFX2TS
Xfifo_from_fft_fifo_cell1_data_out_do_tri[28] fft_data_in[28]
+ fifo_from_fft_fifo_cell1_sr_out[28] FE_OFN1317_n8065 TBUFX2TS
Xfifo_from_fft_fifo_cell1_data_out_do_tri[27] fft_data_in[27]
+ fifo_from_fft_fifo_cell1_sr_out[27] FE_OFN1315_n8065 TBUFX2TS
Xfifo_from_fft_fifo_cell1_data_out_do_tri[26] fft_data_in[26]
+ fifo_from_fft_fifo_cell1_sr_out[26] FE_OFN1316_n8065 TBUFX2TS
Xfifo_from_fft_fifo_cell1_data_out_do_tri[25] fft_data_in[25]
+ fifo_from_fft_fifo_cell1_sr_out[25] FE_OFN1314_n8065 TBUFX2TS
Xfifo_from_fft_fifo_cell1_data_out_do_tri[24] fft_data_in[24]
+ fifo_from_fft_fifo_cell1_sr_out[24] FE_OFN1314_n8065 TBUFX2TS
Xfifo_from_fft_fifo_cell1_data_out_do_tri[23] fft_data_in[23]
+ fifo_from_fft_fifo_cell1_sr_out[23] FE_OFN1019_n649 TBUFX2TS
Xfifo_from_fft_fifo_cell1_data_out_do_tri[22] fft_data_in[22]
+ fifo_from_fft_fifo_cell1_sr_out[22] FE_OFN1021_n649 TBUFX2TS
Xfifo_from_fft_fifo_cell1_data_out_do_tri[21] fft_data_in[21]
+ fifo_from_fft_fifo_cell1_sr_out[21] FE_OFN1021_n649 TBUFX2TS
Xfifo_from_fft_fifo_cell1_data_out_do_tri[20] fft_data_in[20]
+ fifo_from_fft_fifo_cell1_sr_out[20] FE_OFN1019_n649 TBUFX2TS
Xfifo_from_fft_fifo_cell1_data_out_do_tri[19] fft_data_in[19]
+ fifo_from_fft_fifo_cell1_sr_out[19] n649 TBUFX2TS
Xfifo_from_fft_fifo_cell1_data_out_do_tri[18] fft_data_in[18]
+ fifo_from_fft_fifo_cell1_sr_out[18] n649 TBUFX2TS
Xfifo_from_fft_fifo_cell1_data_out_do_tri[17] fft_data_in[17]
+ fifo_from_fft_fifo_cell1_sr_out[17] FE_OFN1018_n649 TBUFX2TS
Xfifo_from_fft_fifo_cell1_data_out_do_tri[16] fft_data_in[16]
+ fifo_from_fft_fifo_cell1_sr_out[16] n649 TBUFX2TS
Xfifo_from_fft_fifo_cell1_data_out_do_tri[15] fft_data_in[15]
+ fifo_from_fft_fifo_cell1_sr_out[15] FE_OFN1019_n649 TBUFX2TS
Xfifo_from_fft_fifo_cell1_data_out_do_tri[14] fft_data_in[14]
+ fifo_from_fft_fifo_cell1_sr_out[14] FE_OFN1018_n649 TBUFX2TS
Xfifo_from_fft_fifo_cell1_data_out_do_tri[13] fft_data_in[13]
+ fifo_from_fft_fifo_cell1_sr_out[13] FE_OFN1020_n649 TBUFX2TS
Xfifo_from_fft_fifo_cell1_data_out_do_tri[12] fft_data_in[12]
+ fifo_from_fft_fifo_cell1_sr_out[12] FE_OFN1018_n649 TBUFX2TS
Xfifo_from_fft_fifo_cell1_data_out_do_tri[11] fft_data_in[11]
+ fifo_from_fft_fifo_cell1_sr_out[11] FE_OFN1020_n649 TBUFX2TS
Xfifo_from_fft_fifo_cell1_data_out_do_tri[10] fft_data_in[10]
+ fifo_from_fft_fifo_cell1_sr_out[10] FE_OFN1021_n649 TBUFX2TS
Xfifo_from_fft_fifo_cell1_data_out_do_tri[9] fft_data_in[9]
+ fifo_from_fft_fifo_cell1_sr_out[9] FE_OFN1021_n649 TBUFX2TS
Xfifo_from_fft_fifo_cell1_data_out_do_tri[8] fft_data_in[8]
+ fifo_from_fft_fifo_cell1_sr_out[8] FE_OFN1020_n649 TBUFX2TS
Xfifo_from_fft_fifo_cell1_data_out_do_tri[7] fft_data_in[7]
+ fifo_from_fft_fifo_cell1_sr_out[7] n8065 TBUFX2TS
Xfifo_from_fft_fifo_cell1_data_out_do_tri[6] fft_data_in[6]
+ fifo_from_fft_fifo_cell1_sr_out[6] n8065 TBUFX2TS
Xfifo_from_fft_fifo_cell1_data_out_do_tri[5] fft_data_in[5]
+ fifo_from_fft_fifo_cell1_sr_out[5] FE_OFN1315_n8065 TBUFX2TS
Xfifo_from_fft_fifo_cell1_data_out_do_tri[4] fft_data_in[4]
+ fifo_from_fft_fifo_cell1_sr_out[4] n8065 TBUFX2TS
Xfifo_from_fft_fifo_cell1_data_out_do_tri[3] fft_data_in[3]
+ fifo_from_fft_fifo_cell1_sr_out[3] FE_OFN1316_n8065 TBUFX2TS
Xfifo_from_fft_fifo_cell1_data_out_do_tri[2] fft_data_in[2]
+ fifo_from_fft_fifo_cell1_sr_out[2] FE_OFN1314_n8065 TBUFX2TS
Xfifo_from_fft_fifo_cell1_data_out_do_tri[1] fft_data_in[1]
+ fifo_from_fft_fifo_cell1_sr_out[1] FE_OFN1315_n8065 TBUFX2TS
Xfifo_from_fft_fifo_cell1_data_out_do_tri[0] fft_data_in[0]
+ fifo_from_fft_fifo_cell1_sr_out[0] FE_OFN1316_n8065 TBUFX2TS
Xfifo_from_fft_fifo_cell0_data_out_do_tri[31] fft_data_in[31]
+ fifo_from_fft_fifo_cell0_sr_out[31] FE_OFN1146_n585 TBUFX2TS
Xfifo_from_fft_fifo_cell0_data_out_do_tri[30] fft_data_in[30]
+ fifo_from_fft_fifo_cell0_sr_out[30] FE_OFN1145_n585 TBUFX2TS
Xfifo_from_fft_fifo_cell0_data_out_do_tri[29] fft_data_in[29]
+ fifo_from_fft_fifo_cell0_sr_out[29] FE_OFN1145_n585 TBUFX2TS
Xfifo_from_fft_fifo_cell0_data_out_do_tri[28] fft_data_in[28]
+ fifo_from_fft_fifo_cell0_sr_out[28] FE_OFN1145_n585 TBUFX2TS
Xfifo_from_fft_fifo_cell0_data_out_do_tri[27] fft_data_in[27]
+ fifo_from_fft_fifo_cell0_sr_out[27] FE_OFN1140_n585 TBUFX2TS
Xfifo_from_fft_fifo_cell0_data_out_do_tri[26] fft_data_in[26]
+ fifo_from_fft_fifo_cell0_sr_out[26] FE_OFN1142_n585 TBUFX2TS
Xfifo_from_fft_fifo_cell0_data_out_do_tri[25] fft_data_in[25]
+ fifo_from_fft_fifo_cell0_sr_out[25] FE_OFN1144_n585 TBUFX2TS
Xfifo_from_fft_fifo_cell0_data_out_do_tri[24] fft_data_in[24]
+ fifo_from_fft_fifo_cell0_sr_out[24] FE_OFN1144_n585 TBUFX2TS
Xfifo_from_fft_fifo_cell0_data_out_do_tri[23] fft_data_in[23]
+ fifo_from_fft_fifo_cell0_sr_out[23] FE_OFN1139_n585 TBUFX2TS
Xfifo_from_fft_fifo_cell0_data_out_do_tri[22] fft_data_in[22]
+ fifo_from_fft_fifo_cell0_sr_out[22] FE_OFN1146_n585 TBUFX2TS
Xfifo_from_fft_fifo_cell0_data_out_do_tri[21] fft_data_in[21]
+ fifo_from_fft_fifo_cell0_sr_out[21] FE_OFN1146_n585 TBUFX2TS
Xfifo_from_fft_fifo_cell0_data_out_do_tri[20] fft_data_in[20]
+ fifo_from_fft_fifo_cell0_sr_out[20] FE_OFN1143_n585 TBUFX2TS
Xfifo_from_fft_fifo_cell0_data_out_do_tri[19] fft_data_in[19]
+ fifo_from_fft_fifo_cell0_sr_out[19] FE_OFN1138_n585 TBUFX2TS
Xfifo_from_fft_fifo_cell0_data_out_do_tri[18] fft_data_in[18]
+ fifo_from_fft_fifo_cell0_sr_out[18] FE_OFN1138_n585 TBUFX2TS
Xfifo_from_fft_fifo_cell0_data_out_do_tri[17] fft_data_in[17]
+ fifo_from_fft_fifo_cell0_sr_out[17] FE_OFN1141_n585 TBUFX2TS
Xfifo_from_fft_fifo_cell0_data_out_do_tri[16] fft_data_in[16]
+ fifo_from_fft_fifo_cell0_sr_out[16] FE_OFN1141_n585 TBUFX2TS
Xfifo_from_fft_fifo_cell0_data_out_do_tri[15] fft_data_in[15]
+ fifo_from_fft_fifo_cell0_sr_out[15] FE_OFN1143_n585 TBUFX2TS
Xfifo_from_fft_fifo_cell0_data_out_do_tri[14] fft_data_in[14]
+ fifo_from_fft_fifo_cell0_sr_out[14] FE_OFN1143_n585 TBUFX2TS
Xfifo_from_fft_fifo_cell0_data_out_do_tri[13] fft_data_in[13]
+ fifo_from_fft_fifo_cell0_sr_out[13] FE_OFN1143_n585 TBUFX2TS
Xfifo_from_fft_fifo_cell0_data_out_do_tri[12] fft_data_in[12]
+ fifo_from_fft_fifo_cell0_sr_out[12] FE_OFN1141_n585 TBUFX2TS
Xfifo_from_fft_fifo_cell0_data_out_do_tri[11] fft_data_in[11]
+ fifo_from_fft_fifo_cell0_sr_out[11] FE_OFN1147_n585 TBUFX2TS
Xfifo_from_fft_fifo_cell0_data_out_do_tri[10] fft_data_in[10]
+ fifo_from_fft_fifo_cell0_sr_out[10] FE_OFN1147_n585 TBUFX2TS
Xfifo_from_fft_fifo_cell0_data_out_do_tri[9] fft_data_in[9]
+ fifo_from_fft_fifo_cell0_sr_out[9] FE_OFN1147_n585 TBUFX2TS
Xfifo_from_fft_fifo_cell0_data_out_do_tri[8] fft_data_in[8]
+ fifo_from_fft_fifo_cell0_sr_out[8] FE_OFN1147_n585 TBUFX2TS
Xfifo_from_fft_fifo_cell0_data_out_do_tri[7] fft_data_in[7]
+ fifo_from_fft_fifo_cell0_sr_out[7] FE_OFN1144_n585 TBUFX2TS
Xfifo_from_fft_fifo_cell0_data_out_do_tri[6] fft_data_in[6]
+ fifo_from_fft_fifo_cell0_sr_out[6] FE_OFN1139_n585 TBUFX2TS
Xfifo_from_fft_fifo_cell0_data_out_do_tri[5] fft_data_in[5]
+ fifo_from_fft_fifo_cell0_sr_out[5] FE_OFN1139_n585 TBUFX2TS
Xfifo_from_fft_fifo_cell0_data_out_do_tri[4] fft_data_in[4]
+ fifo_from_fft_fifo_cell0_sr_out[4] n585 TBUFX2TS
Xfifo_from_fft_fifo_cell0_data_out_do_tri[3] fft_data_in[3]
+ fifo_from_fft_fifo_cell0_sr_out[3] FE_OFN1142_n585 TBUFX2TS
Xfifo_from_fft_fifo_cell0_data_out_do_tri[2] fft_data_in[2]
+ fifo_from_fft_fifo_cell0_sr_out[2] FE_OFN1144_n585 TBUFX2TS
Xfifo_from_fft_fifo_cell0_data_out_do_tri[1] fft_data_in[1]
+ fifo_from_fft_fifo_cell0_sr_out[1] FE_OFN1140_n585 TBUFX2TS
Xfifo_from_fft_fifo_cell0_data_out_do_tri[0] fft_data_in[0]
+ fifo_from_fft_fifo_cell0_sr_out[0] FE_OFN1142_n585 TBUFX2TS
Xfifo_to_fft_fifo_cell15_hold_token_reg fifo_to_fft_hold[15] clk__L1_N0
+ fifo_to_fft_fifo_cell15_N7 DFFQX1TS
Xfifo_to_fir_fifo_cell15_hold_token_reg fifo_to_fir_hold[15] clk__L1_N0
+ fifo_to_fir_fifo_cell15_N7 DFFQX1TS
Xfifo_from_fft_fifo_cell15_hold_token_reg fifo_from_fft_hold[15] clk__L1_N0
+ fifo_from_fft_fifo_cell15_N7 DFFQX1TS
Xrouter_data_cntl_data_bus_tri[30] data_bus[30] router_data_cntl_data_in[30]
+ FE_OFN994_n521 TBUFX2TS
Xrouter_data_cntl_data_bus_tri[29] data_bus[29] router_data_cntl_data_in[29]
+ FE_OFN997_n521 TBUFX2TS
Xrouter_data_cntl_data_bus_tri[28] data_bus[28] router_data_cntl_data_in[28]
+ FE_OFN997_n521 TBUFX2TS
Xrouter_data_cntl_data_bus_tri[23] data_bus[23] router_data_cntl_data_in[23]
+ FE_OFN1001_n521 TBUFX2TS
Xrouter_data_cntl_data_bus_tri[22] data_bus[22] router_data_cntl_data_in[22]
+ FE_OFN1002_n521 TBUFX2TS
Xrouter_data_cntl_data_bus_tri[21] data_bus[21] router_data_cntl_data_in[21]
+ FE_OFN1001_n521 TBUFX2TS
Xrouter_data_cntl_data_bus_tri[20] data_bus[20] router_data_cntl_data_in[20]
+ FE_OFN1000_n521 TBUFX2TS
Xfifo_to_fft_fifo_cell15_controller_valid_read_reg
+ fifo_to_fft_fifo_cell15_controller_valid_read clk__L1_N0 n9519 DFFQX1TS
Xfifo_from_fft_fifo_cell15_controller_valid_read_reg
+ fifo_from_fft_fifo_cell15_controller_valid_read clk__L1_N0 n9523 DFFQX1TS
Xfifo_to_fir_fifo_cell15_controller_valid_read_reg
+ fifo_to_fir_fifo_cell15_controller_valid_read clk__L1_N0 n9527 DFFQX1TS
Xrouter_addr_calc_iir_write_calc_counter_done_reg router_iir_write_done
+ clk__L1_N0 n6765 DFFQX1TS
Xrouter_addr_calc_from_iir_go_reg n8060 router_addr_calc_N191 clk__L1_N0 n7607
+ router_data_from_iir DFFTRX2TS
Xfifo_from_fft_fifo_cell15_reg_ptok_token_reg n4598 fifo_from_fft_hang[14]
+ clk__L1_N0 n4597 n4487 DFFTRX2TS
Xrouter_addr_calc_addr_tri[31] addr[31] n7488 FE_OFN1218_n8064 TBUFX2TS
Xrouter_addr_calc_addr_tri[30] addr[30]
+ FE_OFN1229_router_addr_calc_fft_read_calc_count_30_ FE_OFN1218_n8064 TBUFX2TS
Xrouter_addr_calc_addr_tri[29] addr[29] FE_OFN1234_n7492 FE_OFN1218_n8064
+ TBUFX2TS
Xrouter_addr_calc_addr_tri[28] addr[28] n7497 FE_OFN1221_n8064 TBUFX2TS
Xrouter_addr_calc_addr_tri[27] addr[27]
+ FE_OFN1237_router_addr_calc_fft_read_calc_count_27_ FE_OFN1220_n8064 TBUFX2TS
Xrouter_addr_calc_addr_tri[26] addr[26] n7502 FE_OFN1220_n8064 TBUFX2TS
Xrouter_addr_calc_addr_tri[25] addr[25] n7506 FE_OFN1220_n8064 TBUFX2TS
Xrouter_addr_calc_addr_tri[24] addr[24] n7511 FE_OFN1220_n8064 TBUFX2TS
Xrouter_addr_calc_addr_tri[23] addr[23]
+ FE_OFN1245_router_addr_calc_fft_read_calc_count_23_ FE_OFN857_n7017 TBUFX2TS
Xrouter_addr_calc_addr_tri[22] addr[22] n7516 FE_OFN858_n7017 TBUFX2TS
Xrouter_addr_calc_addr_tri[21] addr[21] n7521 FE_OFN858_n7017 TBUFX2TS
Xrouter_addr_calc_addr_tri[20] addr[20] n7526 FE_OFN861_n7017 TBUFX2TS
Xrouter_addr_calc_addr_tri[19] addr[19]
+ FE_OFN1258_router_addr_calc_fft_read_calc_count_19_ FE_OFN861_n7017 TBUFX2TS
Xrouter_addr_calc_addr_tri[18] addr[18] n7532 FE_OFN859_n7017 TBUFX2TS
Xrouter_addr_calc_addr_tri[17] addr[17] n7536 FE_OFN860_n7017 TBUFX2TS
Xrouter_addr_calc_addr_tri[16] addr[16]
+ FE_OFN1263_router_addr_calc_fft_read_calc_count_16_ FE_OFN860_n7017 TBUFX2TS
Xrouter_addr_calc_addr_tri[15] addr[15] n7541 FE_OFN860_n7017 TBUFX2TS
Xrouter_addr_calc_addr_tri[14] addr[14] n7546 FE_OFN861_n7017 TBUFX2TS
Xrouter_addr_calc_addr_tri[13] addr[13] n7551 FE_OFN861_n7017 TBUFX2TS
Xrouter_addr_calc_addr_tri[12] addr[12] n7556 FE_OFN859_n7017 TBUFX2TS
Xrouter_addr_calc_addr_tri[11] addr[11] n7561 FE_OFN859_n7017 TBUFX2TS
Xrouter_addr_calc_addr_tri[10] addr[10] n7566 FE_OFN857_n7017 TBUFX2TS
Xrouter_addr_calc_addr_tri[9] addr[9] router_addr_calc_fft_read_calc_count[9]
+ FE_OFN857_n7017 TBUFX2TS
Xrouter_addr_calc_addr_tri[8] addr[8] n7571 n7017 TBUFX2TS
Xrouter_addr_calc_addr_tri[7] addr[7] n7576 FE_OFN1222_n8064 TBUFX2TS
Xrouter_addr_calc_addr_tri[6] addr[6] n7581 FE_OFN1222_n8064 TBUFX2TS
Xrouter_addr_calc_addr_tri[5] addr[5]
+ FE_OFN1273_router_addr_calc_fft_read_calc_count_5_ FE_OFN1219_n8064 TBUFX2TS
Xrouter_addr_calc_addr_tri[4] addr[4] n7587 FE_OFN1219_n8064 TBUFX2TS
Xrouter_addr_calc_addr_tri[3] addr[3] n7591 n8064 TBUFX2TS
Xrouter_addr_calc_addr_tri[2] addr[2] n7596 n8064 TBUFX2TS
Xrouter_addr_calc_addr_tri[1] addr[1] n7602 FE_OFN1221_n8064 TBUFX2TS
Xrouter_addr_calc_addr_tri[0] addr[0]
+ FE_OFN1444_router_addr_calc_fft_read_calc_count_0_ FE_OFN1221_n8064 TBUFX2TS
Xrouter_addr_calc_addr_tri2[31] addr[31]
+ FE_OFN1228_router_addr_calc_fft_write_calc_count_31_ FE_OFN1227_n8063
+ TBUFX2TS
Xrouter_addr_calc_addr_tri2[30] addr[30] FE_OFN1232_n7368 n8063 TBUFX2TS
Xrouter_addr_calc_addr_tri2[29] addr[29]
+ FE_OFN1233_router_addr_calc_fft_write_calc_count_29_ FE_OFN1227_n8063
+ TBUFX2TS
Xrouter_addr_calc_addr_tri2[28] addr[28] n7373 FE_OFN1225_n8063 TBUFX2TS
Xrouter_addr_calc_addr_tri2[27] addr[27]
+ FE_OFN1238_router_addr_calc_fft_write_calc_count_27_ FE_OFN1223_n8063
+ TBUFX2TS
Xrouter_addr_calc_addr_tri2[26] addr[26] n7378 FE_OFN1224_n8063 TBUFX2TS
Xrouter_addr_calc_addr_tri2[25] addr[25] n7382 FE_OFN1224_n8063 TBUFX2TS
Xrouter_addr_calc_addr_tri2[24] addr[24] n7387 FE_OFN1224_n8063 TBUFX2TS
Xrouter_addr_calc_addr_tri2[23] addr[23]
+ FE_OFN1246_router_addr_calc_fft_write_calc_count_23_ n7015 TBUFX2TS
Xrouter_addr_calc_addr_tri2[22] addr[22] FE_OFN1249_n7392 FE_OFN862_n7015
+ TBUFX2TS
Xrouter_addr_calc_addr_tri2[21] addr[21] FE_OFN1252_n7397 FE_OFN862_n7015
+ TBUFX2TS
Xrouter_addr_calc_addr_tri2[20] addr[20] FE_OFN1255_n7402 FE_OFN866_n7015
+ TBUFX2TS
Xrouter_addr_calc_addr_tri2[19] addr[19]
+ FE_OFN1259_router_addr_calc_fft_write_calc_count_19_ FE_OFN865_n7015 TBUFX2TS
Xrouter_addr_calc_addr_tri2[18] addr[18] n7408 FE_OFN863_n7015 TBUFX2TS
Xrouter_addr_calc_addr_tri2[17] addr[17] n7412 FE_OFN865_n7015 TBUFX2TS
Xrouter_addr_calc_addr_tri2[16] addr[16] n7417 FE_OFN865_n7015 TBUFX2TS
Xrouter_addr_calc_addr_tri2[15] addr[15]
+ router_addr_calc_fft_write_calc_count[15] FE_OFN866_n7015 TBUFX2TS
Xrouter_addr_calc_addr_tri2[14] addr[14] n7422 FE_OFN866_n7015 TBUFX2TS
Xrouter_addr_calc_addr_tri2[13] addr[13] n7427 FE_OFN866_n7015 TBUFX2TS
Xrouter_addr_calc_addr_tri2[12] addr[12] n7432 FE_OFN863_n7015 TBUFX2TS
Xrouter_addr_calc_addr_tri2[11] addr[11] n7437 FE_OFN864_n7015 TBUFX2TS
Xrouter_addr_calc_addr_tri2[10] addr[10] n7442 FE_OFN864_n7015 TBUFX2TS
Xrouter_addr_calc_addr_tri2[9] addr[9]
+ FE_OFN1268_router_addr_calc_fft_write_calc_count_9_ FE_OFN864_n7015 TBUFX2TS
Xrouter_addr_calc_addr_tri2[8] addr[8] n7447 FE_OFN864_n7015 TBUFX2TS
Xrouter_addr_calc_addr_tri2[7] addr[7] n7452 FE_OFN1226_n8063 TBUFX2TS
Xrouter_addr_calc_addr_tri2[6] addr[6] n7457 FE_OFN1227_n8063 TBUFX2TS
Xrouter_addr_calc_addr_tri2[5] addr[5] n7463 FE_OFN1223_n8063 TBUFX2TS
Xrouter_addr_calc_addr_tri2[4] addr[4] n7468 FE_OFN1226_n8063 TBUFX2TS
Xrouter_addr_calc_addr_tri2[3] addr[3] n7472 FE_OFN1225_n8063 TBUFX2TS
Xrouter_addr_calc_addr_tri2[2] addr[2] n7477 FE_OFN1225_n8063 TBUFX2TS
Xrouter_addr_calc_addr_tri2[1] addr[1] n7483 FE_OFN1224_n8063 TBUFX2TS
Xrouter_addr_calc_addr_tri2[0] addr[0]
+ FE_OFN1443_router_addr_calc_fft_write_calc_count_0_ FE_OFN1226_n8063 TBUFX2TS
Xrouter_addr_calc_addr_tri3[31] addr[31] n7250 n8062 TBUFX2TS
Xrouter_addr_calc_addr_tri3[30] addr[30]
+ FE_OFN1230_router_addr_calc_fir_read_calc_count_30_ n8062 TBUFX2TS
Xrouter_addr_calc_addr_tri3[29] addr[29] FE_OFN1235_n7254 n8062 TBUFX2TS
Xrouter_addr_calc_addr_tri3[28] addr[28] FE_OFN1236_n7259 FE_OFN1209_n8062
+ TBUFX2TS
Xrouter_addr_calc_addr_tri3[27] addr[27]
+ FE_OFN1239_router_addr_calc_fir_read_calc_count_27_ FE_OFN1210_n8062 TBUFX2TS
Xrouter_addr_calc_addr_tri3[26] addr[26] FE_OFN1241_n7264 FE_OFN1211_n8062
+ TBUFX2TS
Xrouter_addr_calc_addr_tri3[25] addr[25] FE_OFN1242_n7268 FE_OFN1211_n8062
+ TBUFX2TS
Xrouter_addr_calc_addr_tri3[24] addr[24] FE_OFN1243_n7273 FE_OFN1211_n8062
+ TBUFX2TS
Xrouter_addr_calc_addr_tri3[23] addr[23]
+ FE_OFN1247_router_addr_calc_fir_read_calc_count_23_ FE_OFN850_n7016 TBUFX2TS
Xrouter_addr_calc_addr_tri3[22] addr[22] FE_OFN1250_n7278 FE_OFN849_n7016
+ TBUFX2TS
Xrouter_addr_calc_addr_tri3[21] addr[21] FE_OFN1253_n7283 FE_OFN850_n7016
+ TBUFX2TS
Xrouter_addr_calc_addr_tri3[20] addr[20] FE_OFN1256_n7288 FE_OFN851_n7016
+ TBUFX2TS
Xrouter_addr_calc_addr_tri3[19] addr[19]
+ FE_OFN1260_router_addr_calc_fir_read_calc_count_19_ FE_OFN852_n7016 TBUFX2TS
Xrouter_addr_calc_addr_tri3[18] addr[18] n7294 FE_OFN849_n7016 TBUFX2TS
Xrouter_addr_calc_addr_tri3[17] addr[17] FE_OFN1262_n7298 FE_OFN852_n7016
+ TBUFX2TS
Xrouter_addr_calc_addr_tri3[16] addr[16] FE_OFN1265_n7303 FE_OFN852_n7016
+ TBUFX2TS
Xrouter_addr_calc_addr_tri3[15] addr[15]
+ router_addr_calc_fir_read_calc_count[15] FE_OFN852_n7016 TBUFX2TS
Xrouter_addr_calc_addr_tri3[14] addr[14] FE_OFN1277_n7308 FE_OFN851_n7016
+ TBUFX2TS
Xrouter_addr_calc_addr_tri3[13] addr[13] n7313 FE_OFN851_n7016 TBUFX2TS
Xrouter_addr_calc_addr_tri3[12] addr[12] n7318 FE_OFN850_n7016 TBUFX2TS
Xrouter_addr_calc_addr_tri3[11] addr[11] n7323 FE_OFN849_n7016 TBUFX2TS
Xrouter_addr_calc_addr_tri3[10] addr[10] FE_OFN1279_n7328 n7016 TBUFX2TS
Xrouter_addr_calc_addr_tri3[9] addr[9]
+ FE_OFN1269_router_addr_calc_fir_read_calc_count_9_ n7016 TBUFX2TS
Xrouter_addr_calc_addr_tri3[8] addr[8] FE_OFN1278_n7333 n7016 TBUFX2TS
Xrouter_addr_calc_addr_tri3[7] addr[7] n7338 FE_OFN1210_n8062 TBUFX2TS
Xrouter_addr_calc_addr_tri3[6] addr[6] n7343 FE_OFN1210_n8062 TBUFX2TS
Xrouter_addr_calc_addr_tri3[5] addr[5]
+ FE_OFN1824_router_addr_calc_fir_read_calc_count_5_ FE_OFN1208_n8062 TBUFX2TS
Xrouter_addr_calc_addr_tri3[4] addr[4] n7349 FE_OFN1211_n8062 TBUFX2TS
Xrouter_addr_calc_addr_tri3[3] addr[3] FE_OFN1275_n7353 FE_OFN1208_n8062
+ TBUFX2TS
Xrouter_addr_calc_addr_tri3[2] addr[2] FE_OFN1274_n7358 FE_OFN1208_n8062
+ TBUFX2TS
Xrouter_addr_calc_addr_tri3[1] addr[1] n7364 FE_OFN1209_n8062 TBUFX2TS
Xrouter_addr_calc_addr_tri3[0] addr[0]
+ FE_OFN1446_router_addr_calc_fir_read_calc_count_0_ FE_OFN1210_n8062 TBUFX2TS
Xrouter_addr_calc_addr_tri4[31] addr[31] n7119 n8061 TBUFX2TS
Xrouter_addr_calc_addr_tri4[30] addr[30]
+ FE_OFN1231_router_addr_calc_fir_write_calc_count_30_ FE_OFN1213_n8061
+ TBUFX2TS
Xrouter_addr_calc_addr_tri4[29] addr[29] n7124 n8061 TBUFX2TS
Xrouter_addr_calc_addr_tri4[28] addr[28] n7130 FE_OFN1213_n8061 TBUFX2TS
Xrouter_addr_calc_addr_tri4[27] addr[27]
+ FE_OFN1240_router_addr_calc_fir_write_calc_count_27_ FE_OFN1215_n8061
+ TBUFX2TS
Xrouter_addr_calc_addr_tri4[26] addr[26] n7136 FE_OFN1213_n8061 TBUFX2TS
Xrouter_addr_calc_addr_tri4[25] addr[25] n7141 FE_OFN1216_n8061 TBUFX2TS
Xrouter_addr_calc_addr_tri4[24] addr[24] n7147 FE_OFN1216_n8061 TBUFX2TS
Xrouter_addr_calc_addr_tri4[23] addr[23]
+ FE_OFN1248_router_addr_calc_fir_write_calc_count_23_ n7018 TBUFX2TS
Xrouter_addr_calc_addr_tri4[22] addr[22] FE_OFN1251_n7153 FE_OFN853_n7018
+ TBUFX2TS
Xrouter_addr_calc_addr_tri4[21] addr[21] FE_OFN1254_n7159 FE_OFN853_n7018
+ TBUFX2TS
Xrouter_addr_calc_addr_tri4[20] addr[20] FE_OFN1257_n7165 FE_OFN855_n7018
+ TBUFX2TS
Xrouter_addr_calc_addr_tri4[19] addr[19]
+ FE_OFN1261_router_addr_calc_fir_write_calc_count_19_ FE_OFN855_n7018 TBUFX2TS
Xrouter_addr_calc_addr_tri4[18] addr[18] n7172 FE_OFN855_n7018 TBUFX2TS
Xrouter_addr_calc_addr_tri4[17] addr[17] n7177 FE_OFN854_n7018 TBUFX2TS
Xrouter_addr_calc_addr_tri4[16] addr[16]
+ FE_OFN1264_router_addr_calc_fir_write_calc_count_16_ FE_OFN856_n7018 TBUFX2TS
Xrouter_addr_calc_addr_tri4[15] addr[15] n7183 FE_OFN856_n7018 TBUFX2TS
Xrouter_addr_calc_addr_tri4[14] addr[14] n7189 FE_OFN856_n7018 TBUFX2TS
Xrouter_addr_calc_addr_tri4[13] addr[13] n7195 FE_OFN856_n7018 TBUFX2TS
Xrouter_addr_calc_addr_tri4[12] addr[12] n7201 FE_OFN854_n7018 TBUFX2TS
Xrouter_addr_calc_addr_tri4[11] addr[11] n7205 FE_OFN854_n7018 TBUFX2TS
Xrouter_addr_calc_addr_tri4[10] addr[10] n7209 FE_OFN854_n7018 TBUFX2TS
Xrouter_addr_calc_addr_tri4[9] addr[9]
+ FE_OFN1266_router_addr_calc_fir_write_calc_count_9_ n7018 TBUFX2TS
Xrouter_addr_calc_addr_tri4[8] addr[8] n7214 n7018 TBUFX2TS
Xrouter_addr_calc_addr_tri4[7] addr[7] n7219 FE_OFN1216_n8061 TBUFX2TS
Xrouter_addr_calc_addr_tri4[6] addr[6] n7224 FE_OFN1215_n8061 TBUFX2TS
Xrouter_addr_calc_addr_tri4[5] addr[5]
+ FE_OFN1272_router_addr_calc_fir_write_calc_count_5_ FE_OFN1214_n8061 TBUFX2TS
Xrouter_addr_calc_addr_tri4[4] addr[4] n7230 FE_OFN1214_n8061 TBUFX2TS
Xrouter_addr_calc_addr_tri4[3] addr[3] n7234 FE_OFN1212_n8061 TBUFX2TS
Xrouter_addr_calc_addr_tri4[2] addr[2] n7239 FE_OFN1214_n8061 TBUFX2TS
Xrouter_addr_calc_addr_tri4[1] addr[1] n7245 FE_OFN1215_n8061 TBUFX2TS
Xrouter_addr_calc_addr_tri4[0] addr[0]
+ FE_OFN1445_router_addr_calc_fir_write_calc_count_0_ FE_OFN1212_n8061 TBUFX2TS
Xrouter_addr_calc_addr_tri5[31] addr[31]
+ router_addr_calc_iir_read_calc_count[31] VSS TBUFX2TS
Xrouter_addr_calc_addr_tri5[30] addr[30]
+ router_addr_calc_iir_read_calc_count[30] VSS TBUFX2TS
Xrouter_addr_calc_addr_tri5[29] addr[29]
+ router_addr_calc_iir_read_calc_count[29] VSS TBUFX2TS
Xrouter_addr_calc_addr_tri5[28] addr[28]
+ router_addr_calc_iir_read_calc_count[28] VSS TBUFX2TS
Xrouter_addr_calc_addr_tri5[27] addr[27]
+ router_addr_calc_iir_read_calc_count[27] VSS TBUFX2TS
Xrouter_addr_calc_addr_tri5[26] addr[26]
+ router_addr_calc_iir_read_calc_count[26] VSS TBUFX2TS
Xrouter_addr_calc_addr_tri5[25] addr[25]
+ router_addr_calc_iir_read_calc_count[25] VSS TBUFX2TS
Xrouter_addr_calc_addr_tri5[24] addr[24]
+ router_addr_calc_iir_read_calc_count[24] VSS TBUFX2TS
Xrouter_addr_calc_addr_tri5[23] addr[23]
+ router_addr_calc_iir_read_calc_count[23] VSS TBUFX2TS
Xrouter_addr_calc_addr_tri5[22] addr[22]
+ router_addr_calc_iir_read_calc_count[22] VSS TBUFX2TS
Xrouter_addr_calc_addr_tri5[21] addr[21]
+ router_addr_calc_iir_read_calc_count[21] VSS TBUFX2TS
Xrouter_addr_calc_addr_tri5[20] addr[20]
+ router_addr_calc_iir_read_calc_count[20] VSS TBUFX2TS
Xrouter_addr_calc_addr_tri5[19] addr[19]
+ router_addr_calc_iir_read_calc_count[19] VSS TBUFX2TS
Xrouter_addr_calc_addr_tri5[18] addr[18]
+ router_addr_calc_iir_read_calc_count[18] VSS TBUFX2TS
Xrouter_addr_calc_addr_tri5[17] addr[17]
+ router_addr_calc_iir_read_calc_count[17] VSS TBUFX2TS
Xrouter_addr_calc_addr_tri5[16] addr[16]
+ router_addr_calc_iir_read_calc_count[16] VSS TBUFX2TS
Xrouter_addr_calc_addr_tri5[15] addr[15]
+ router_addr_calc_iir_read_calc_count[15] VSS TBUFX2TS
Xrouter_addr_calc_addr_tri5[14] addr[14]
+ router_addr_calc_iir_read_calc_count[14] VSS TBUFX2TS
Xrouter_addr_calc_addr_tri5[13] addr[13]
+ router_addr_calc_iir_read_calc_count[13] VSS TBUFX2TS
Xrouter_addr_calc_addr_tri5[12] addr[12]
+ router_addr_calc_iir_read_calc_count[12] VSS TBUFX2TS
Xrouter_addr_calc_addr_tri5[11] addr[11]
+ router_addr_calc_iir_read_calc_count[11] VSS TBUFX2TS
Xrouter_addr_calc_addr_tri5[10] addr[10]
+ router_addr_calc_iir_read_calc_count[10] VSS TBUFX2TS
Xrouter_addr_calc_addr_tri5[9] addr[9] router_addr_calc_iir_read_calc_count[9]
+ VSS TBUFX2TS
Xrouter_addr_calc_addr_tri5[8] addr[8] router_addr_calc_iir_read_calc_count[8]
+ VSS TBUFX2TS
Xrouter_addr_calc_addr_tri5[7] addr[7] router_addr_calc_iir_read_calc_count[7]
+ VSS TBUFX2TS
Xrouter_addr_calc_addr_tri5[6] addr[6] router_addr_calc_iir_read_calc_count[6]
+ VSS TBUFX2TS
Xrouter_addr_calc_addr_tri5[5] addr[5] router_addr_calc_iir_read_calc_count[5]
+ VSS TBUFX2TS
Xrouter_addr_calc_addr_tri5[4] addr[4] router_addr_calc_iir_read_calc_count[4]
+ VSS TBUFX2TS
Xrouter_addr_calc_addr_tri5[3] addr[3] router_addr_calc_iir_read_calc_count[3]
+ VSS TBUFX2TS
Xrouter_addr_calc_addr_tri5[2] addr[2] router_addr_calc_iir_read_calc_count[2]
+ VSS TBUFX2TS
Xrouter_addr_calc_addr_tri5[1] addr[1] router_addr_calc_iir_read_calc_count[1]
+ VSS TBUFX2TS
Xrouter_addr_calc_addr_tri5[0] addr[0] router_addr_calc_iir_read_calc_count[0]
+ VSS TBUFX2TS
Xrouter_addr_calc_addr_tri6[31] addr[31] n7199 FE_OFN1305_n8060 TBUFX2TS
Xrouter_addr_calc_addr_tri6[29] addr[29] n7193 FE_OFN1305_n8060 TBUFX2TS
Xrouter_addr_calc_addr_tri6[28] addr[28] n7187 FE_OFN1302_n8060 TBUFX2TS
Xrouter_addr_calc_addr_tri6[27] addr[27]
+ router_addr_calc_iir_write_calc_count[27] FE_OFN1302_n8060 TBUFX2TS
Xrouter_addr_calc_addr_tri6[26] addr[26] n7181 FE_OFN1301_n8060 TBUFX2TS
Xrouter_addr_calc_addr_tri6[25] addr[25] n7174 FE_OFN1301_n8060 TBUFX2TS
Xrouter_addr_calc_addr_tri6[24] addr[24] n7168 FE_OFN1301_n8060 TBUFX2TS
Xrouter_addr_calc_addr_tri6[23] addr[23]
+ FE_OFN1244_router_addr_calc_iir_write_calc_count_23_ FE_OFN1007_n137 TBUFX2TS
Xrouter_addr_calc_addr_tri6[22] addr[22] n7162 FE_OFN1007_n137 TBUFX2TS
Xrouter_addr_calc_addr_tri6[21] addr[21] n7156 FE_OFN1007_n137 TBUFX2TS
Xrouter_addr_calc_addr_tri6[20] addr[20] n7150 FE_OFN1005_n137 TBUFX2TS
Xrouter_addr_calc_addr_tri6[19] addr[19]
+ router_addr_calc_iir_write_calc_count[19] FE_OFN1008_n137 TBUFX2TS
Xrouter_addr_calc_addr_tri6[18] addr[18] n7145 FE_OFN1006_n137 TBUFX2TS
Xrouter_addr_calc_addr_tri6[17] addr[17] n7138 FE_OFN1008_n137 TBUFX2TS
Xrouter_addr_calc_addr_tri6[16] addr[16]
+ router_addr_calc_iir_write_calc_count[16] FE_OFN1008_n137 TBUFX2TS
Xrouter_addr_calc_addr_tri6[15] addr[15] n7132 FE_OFN1005_n137 TBUFX2TS
Xrouter_addr_calc_addr_tri6[14] addr[14] n7126 FE_OFN1008_n137 TBUFX2TS
Xrouter_addr_calc_addr_tri6[13] addr[13] n7121 FE_OFN1005_n137 TBUFX2TS
Xrouter_addr_calc_addr_tri6[12] addr[12] n7115 FE_OFN1006_n137 TBUFX2TS
Xrouter_addr_calc_addr_tri6[11] addr[11] n7109 FE_OFN1006_n137 TBUFX2TS
Xrouter_addr_calc_addr_tri6[10] addr[10] n7104 FE_OFN1004_n137 TBUFX2TS
Xrouter_addr_calc_addr_tri6[9] addr[9]
+ FE_OFN1280_router_addr_calc_iir_write_calc_count_9_ n137 TBUFX2TS
Xrouter_addr_calc_addr_tri6[8] addr[8] n7098 FE_OFN1004_n137 TBUFX2TS
Xrouter_addr_calc_addr_tri6[7] addr[7] n7092 FE_OFN1303_n8060 TBUFX2TS
Xrouter_addr_calc_addr_tri6[6] addr[6] n7089 FE_OFN1303_n8060 TBUFX2TS
Xrouter_addr_calc_addr_tri6[5] addr[5] router_addr_calc_iir_write_calc_count[5]
+ FE_OFN1304_n8060 TBUFX2TS
Xrouter_addr_calc_addr_tri6[4] addr[4] n7096 FE_OFN1305_n8060 TBUFX2TS
Xrouter_addr_calc_addr_tri6[3] addr[3] n7101 FE_OFN1304_n8060 TBUFX2TS
Xrouter_addr_calc_addr_tri6[1] addr[1] n7113 n8060 TBUFX2TS
Xrouter_addr_calc_addr_tri6[0] addr[0]
+ FE_OFN1442_router_addr_calc_iir_write_calc_count_0_ FE_OFN1303_n8060 TBUFX2TS
Xfifo_from_fir_fifo_cell15_hold_token_reg fifo_from_fir_hold[15] clk__L1_N0
+ fifo_from_fir_fifo_cell15_N7 DFFQX1TS
Xrouter_data_cntl_ram_write_reg router_ram_write_enable_reg clk__L1_N0 n6763
+ DFFQX1TS
Xrouter_data_cntl_iir_full_flag_reg router_data_cntl_N151 clk__L1_N0 n5461
+ DFFQX1TS
Xfifo_to_fft_fifo_cell13_reg_gtok_token_reg
+ fifo_to_fft_fifo_cell13_reg_gtok_token clk__L1_N0 n5475 DFFQX1TS
Xfifo_to_fft_fifo_cell14_reg_gtok_token_reg
+ fifo_to_fft_fifo_cell14_reg_gtok_token clk__L1_N0 n5472 DFFQX1TS
Xfifo_to_fir_fifo_cell13_reg_gtok_token_reg
+ fifo_to_fir_fifo_cell13_reg_gtok_token clk__L1_N0 n5527 DFFQX1TS
Xfifo_to_fir_fifo_cell14_reg_gtok_token_reg
+ fifo_to_fir_fifo_cell14_reg_gtok_token clk__L1_N0 n5524 DFFQX1TS
Xfifo_from_fir_fifo_cell14_reg_gtok_token_reg
+ fifo_from_fir_fifo_cell14_reg_gtok_token clk__L1_N0 n6746 DFFQX1TS
Xfifo_from_fft_fifo_cell14_reg_gtok_token_reg
+ fifo_from_fft_fifo_cell14_reg_gtok_token clk__L1_N0 n6217 DFFQX1TS
Xrouter_data_cntl_data_bus_tri[27] data_bus[27] router_data_cntl_data_in[27]
+ FE_OFN994_n521 TBUFX2TS
Xrouter_data_cntl_data_bus_tri[26] data_bus[26] router_data_cntl_data_in[26]
+ FE_OFN998_n521 TBUFX2TS
Xrouter_data_cntl_data_bus_tri[25] data_bus[25] router_data_cntl_data_in[25]
+ n521 TBUFX2TS
Xrouter_data_cntl_data_bus_tri[24] data_bus[24] router_data_cntl_data_in[24]
+ n521 TBUFX2TS
Xrouter_data_cntl_data_bus_tri[19] data_bus[19] router_data_cntl_data_in[19]
+ FE_OFN998_n521 TBUFX2TS
Xrouter_data_cntl_data_bus_tri[18] data_bus[18] router_data_cntl_data_in[18]
+ FE_OFN999_n521 TBUFX2TS
Xrouter_data_cntl_data_bus_tri[17] data_bus[17] router_data_cntl_data_in[17]
+ FE_OFN999_n521 TBUFX2TS
Xrouter_data_cntl_data_bus_tri[16] data_bus[16] router_data_cntl_data_in[16]
+ FE_OFN997_n521 TBUFX2TS
Xrouter_data_cntl_data_bus_tri[15] data_bus[15] router_data_cntl_data_in[15]
+ FE_OFN1002_n521 TBUFX2TS
Xrouter_data_cntl_data_bus_tri[14] data_bus[14] router_data_cntl_data_in[14]
+ FE_OFN1000_n521 TBUFX2TS
Xrouter_data_cntl_data_bus_tri[13] data_bus[13] router_data_cntl_data_in[13]
+ FE_OFN1003_n521 TBUFX2TS
Xrouter_data_cntl_data_bus_tri[12] data_bus[12] router_data_cntl_data_in[12]
+ FE_OFN1000_n521 TBUFX2TS
Xrouter_data_cntl_data_bus_tri[11] data_bus[11] router_data_cntl_data_in[11]
+ FE_OFN1003_n521 TBUFX2TS
Xrouter_data_cntl_data_bus_tri[10] data_bus[10] router_data_cntl_data_in[10]
+ FE_OFN1001_n521 TBUFX2TS
Xrouter_data_cntl_data_bus_tri[9] data_bus[9] router_data_cntl_data_in[9]
+ FE_OFN1003_n521 TBUFX2TS
Xrouter_data_cntl_data_bus_tri[8] data_bus[8] router_data_cntl_data_in[8]
+ FE_OFN1002_n521 TBUFX2TS
Xrouter_data_cntl_data_bus_tri[7] data_bus[7] router_data_cntl_data_in[7]
+ FE_OFN994_n521 TBUFX2TS
Xrouter_data_cntl_data_bus_tri[6] data_bus[6] router_data_cntl_data_in[6]
+ FE_OFN996_n521 TBUFX2TS
Xrouter_data_cntl_data_bus_tri[5] data_bus[5] router_data_cntl_data_in[5] n521
+ TBUFX2TS
Xrouter_data_cntl_data_bus_tri[4] data_bus[4] router_data_cntl_data_in[4]
+ FE_OFN995_n521 TBUFX2TS
Xrouter_data_cntl_data_bus_tri[3] data_bus[3] router_data_cntl_data_in[3]
+ FE_OFN998_n521 TBUFX2TS
Xrouter_data_cntl_data_bus_tri[2] data_bus[2] router_data_cntl_data_in[2]
+ FE_OFN996_n521 TBUFX2TS
Xrouter_data_cntl_data_bus_tri[1] data_bus[1] router_data_cntl_data_in[1]
+ FE_OFN995_n521 TBUFX2TS
Xrouter_data_cntl_data_bus_tri[0] data_bus[0] router_data_cntl_data_in[0]
+ FE_OFN999_n521 TBUFX2TS
Xrouter_data_cntl_data_bus_tri[31] data_bus[31] router_data_cntl_data_in[31]
+ FE_OFN995_n521 TBUFX2TS
Xfifo_to_fir_fifo_cell0_reg_ptok_token_reg fifo_to_fir_tok_xnor_put clk__L1_N0
+ n5570 DFFQX1TS
Xfifo_to_fft_fifo_cell0_reg_ptok_token_reg fifo_to_fft_tok_xnor_put clk__L1_N0
+ n5518 DFFQX1TS
Xrouter_data_cntl_fft_full_flag_reg router_data_cntl_fft_full_flag clk__L1_N0
+ n5460 DFFQX1TS
Xfifo_to_fft_fifo_cell14_controller_valid_read_reg
+ fifo_to_fft_fifo_cell14_controller_valid_read clk__L1_N0 n9519 DFFQX1TS
Xfifo_to_fir_fifo_cell14_controller_valid_read_reg
+ fifo_to_fir_fifo_cell14_controller_valid_read clk__L1_N0 n9527 DFFQX1TS
Xfifo_from_fir_fifo_cell15_controller_valid_read_reg
+ fifo_from_fir_fifo_cell15_controller_valid_read clk__L1_N0 n9516 DFFQX1TS
Xfifo_from_fir_fifo_cell15_reg_ptok_token_reg n4784 fifo_from_fir_hang[14]
+ clk__L1_N0 n4783 n4673 DFFTRX2TS
Xfifo_to_fft_fifo_cell14_reg_ptok_token_reg n3964 fifo_to_fft_hang[13]
+ clk__L1_N0 n3963 n3878 DFFTRX2TS
Xfifo_to_fir_fifo_cell14_reg_ptok_token_reg n4139 fifo_to_fir_hang[13]
+ clk__L1_N0 n4138 n4053 DFFTRX2TS
Xrouter_addr_calc_addr_tri6[30] addr[30]
+ router_addr_calc_iir_write_calc_count[30] n8060 TBUFX2TS
Xrouter_addr_calc_addr_tri6[2] addr[2] FE_OFN1825_n7107 FE_OFN1304_n8060
+ TBUFX2TS
Xrouter_pla_top_iir_enable_reg iir_enable clk__L1_N0 n6764 DFFQX1TS
Xfifo_to_fft_fifo_cell11_reg_gtok_token_reg
+ fifo_to_fft_fifo_cell11_reg_gtok_token clk__L1_N0 n5481 DFFQX1TS
Xfifo_to_fft_fifo_cell12_reg_gtok_token_reg
+ fifo_to_fft_fifo_cell12_reg_gtok_token clk__L1_N0 n5478 DFFQX1TS
Xfifo_to_fir_fifo_cell11_reg_gtok_token_reg
+ fifo_to_fir_fifo_cell11_reg_gtok_token clk__L1_N0 n5533 DFFQX1TS
Xfifo_to_fir_fifo_cell12_reg_gtok_token_reg
+ fifo_to_fir_fifo_cell12_reg_gtok_token clk__L1_N0 n5530 DFFQX1TS
Xfifo_from_fft_fifo_cell13_reg_gtok_token_reg
+ fifo_from_fft_fifo_cell13_reg_gtok_token clk__L1_N0 n6218 DFFQX1TS
Xrouter_data_cntl_iir_get_req_reg router_iir_get_req_reg clk__L1_N0 n6762
+ DFFQX1TS
Xfifo_from_fft_fifo_cell0_reg_ptok_token_reg fifo_from_fft_tok_xnor_put
+ clk__L1_N0 n5419 DFFQX1TS
Xfifo_to_fft_fifo_cell13_controller_valid_read_reg
+ fifo_to_fft_fifo_cell13_controller_valid_read clk__L1_N0 n9519 DFFQX1TS
Xfifo_from_fft_fifo_cell14_controller_valid_read_reg
+ fifo_from_fft_fifo_cell14_controller_valid_read clk__L1_N0 n9523 DFFQX1TS
Xfifo_to_fir_fifo_cell13_controller_valid_read_reg
+ fifo_to_fir_fifo_cell13_controller_valid_read clk__L1_N0 n9527 DFFQX1TS
Xfifo_from_fir_fifo_cell14_reg_ptok_token_reg n4787 fifo_from_fir_hang[13]
+ clk__L1_N0 n4786 n4671 DFFTRX2TS
Xfifo_to_fft_fifo_cell12_reg_ptok_token_reg n3970 fifo_to_fft_hang[11]
+ clk__L1_N0 n3969 n3874 DFFTRX2TS
Xfifo_to_fft_fifo_cell13_reg_ptok_token_reg n3967 fifo_to_fft_hang[12]
+ clk__L1_N0 n3966 n3876 DFFTRX2TS
Xfifo_to_fir_fifo_cell12_reg_ptok_token_reg n4145 fifo_to_fir_hang[11]
+ clk__L1_N0 n4144 n4049 DFFTRX2TS
Xfifo_to_fir_fifo_cell13_reg_ptok_token_reg n4142 fifo_to_fir_hang[12]
+ clk__L1_N0 n4141 n4051 DFFTRX2TS
Xfifo_from_fft_fifo_cell14_reg_ptok_token_reg n4601 fifo_from_fft_hang[13]
+ clk__L1_N0 n4600 n4485 DFFTRX2TS
Xrouter_data_cntl_ram_read_reg router_ram_read_enable_reg clk__L1_N0 n6233
+ DFFQX1TS
Xfifo_from_fir_fifo_cell13_reg_gtok_token_reg
+ fifo_from_fir_fifo_cell13_reg_gtok_token clk__L1_N0 n6747 DFFQX1TS
Xfifo_from_fir_fifo_cell0_reg_ptok_token_reg fifo_from_fir_tok_xnor_put
+ clk__L1_N0 n5384 DFFQX1TS
Xfifo_to_fft_fifo_cell11_controller_valid_read_reg
+ fifo_to_fft_fifo_cell11_controller_valid_read clk__L1_N0 n9518 DFFQX1TS
Xfifo_to_fft_fifo_cell12_controller_valid_read_reg
+ fifo_to_fft_fifo_cell12_controller_valid_read clk__L1_N0 n9527 DFFQX1TS
Xfifo_to_fir_fifo_cell11_controller_valid_read_reg
+ fifo_to_fir_fifo_cell11_controller_valid_read clk__L1_N0 n9526 DFFQX1TS
Xfifo_to_fir_fifo_cell12_controller_valid_read_reg
+ fifo_to_fir_fifo_cell12_controller_valid_read clk__L1_N0 n9526 DFFQX1TS
Xfifo_from_fir_fifo_cell14_controller_valid_read_reg
+ fifo_from_fir_fifo_cell14_controller_valid_read clk__L1_N0 n9529 DFFQX1TS
Xfifo_to_fft_fifo_cell11_reg_ptok_token_reg n3973 fifo_to_fft_hang[10]
+ clk__L1_N0 n3972 n3872 DFFTRX2TS
Xfifo_to_fir_fifo_cell11_reg_ptok_token_reg n4148 fifo_to_fir_hang[10]
+ clk__L1_N0 n4147 n4047 DFFTRX2TS
Xfifo_from_fft_fifo_cell13_reg_ptok_token_reg n4604 fifo_from_fft_hang[12]
+ clk__L1_N0 n4603 n4483 DFFTRX2TS
Xfifo_to_fft_fifo_cell9_reg_gtok_token_reg
+ fifo_to_fft_fifo_cell9_reg_gtok_token clk__L1_N0 n5487 DFFQX1TS
Xfifo_to_fft_fifo_cell10_reg_gtok_token_reg
+ fifo_to_fft_fifo_cell10_reg_gtok_token clk__L1_N0 n5484 DFFQX1TS
Xfifo_to_fir_fifo_cell9_reg_gtok_token_reg
+ fifo_to_fir_fifo_cell9_reg_gtok_token clk__L1_N0 n5539 DFFQX1TS
Xfifo_to_fir_fifo_cell10_reg_gtok_token_reg
+ fifo_to_fir_fifo_cell10_reg_gtok_token clk__L1_N0 n5536 DFFQX1TS
Xfifo_from_fir_fifo_cell12_reg_gtok_token_reg
+ fifo_from_fir_fifo_cell12_reg_gtok_token clk__L1_N0 n6748 DFFQX1TS
Xfifo_from_fft_fifo_cell12_reg_gtok_token_reg
+ fifo_from_fft_fifo_cell12_reg_gtok_token clk__L1_N0 n6219 DFFQX1TS
Xfifo_to_fft_fifo_cell10_controller_valid_read_reg
+ fifo_to_fft_fifo_cell10_controller_valid_read clk__L1_N0 n9518 DFFQX1TS
Xfifo_from_fft_fifo_cell13_controller_valid_read_reg
+ fifo_from_fft_fifo_cell13_controller_valid_read clk__L1_N0 n9523 DFFQX1TS
Xfifo_to_fir_fifo_cell10_controller_valid_read_reg
+ fifo_to_fir_fifo_cell10_controller_valid_read clk__L1_N0 n9516 DFFQX1TS
Xfifo_from_fir_fifo_cell13_controller_valid_read_reg
+ fifo_from_fir_fifo_cell13_controller_valid_read clk__L1_N0 n9531 DFFQX1TS
Xfifo_from_fir_fifo_cell13_reg_ptok_token_reg n4790 fifo_from_fir_hang[12]
+ clk__L1_N0 n4789 n4669 DFFTRX2TS
Xfifo_to_fft_fifo_cell9_reg_ptok_token_reg n3979 fifo_to_fft_hang[8] clk__L1_N0
+ n3978 n3868 DFFTRX2TS
Xfifo_to_fft_fifo_cell10_reg_ptok_token_reg n3976 fifo_to_fft_hang[9]
+ clk__L1_N0 n3975 n3870 DFFTRX2TS
Xfifo_to_fir_fifo_cell9_reg_ptok_token_reg n4154 fifo_to_fir_hang[8] clk__L1_N0
+ n4153 n4043 DFFTRX2TS
Xfifo_to_fir_fifo_cell10_reg_ptok_token_reg n4151 fifo_to_fir_hang[9]
+ clk__L1_N0 n4150 n4045 DFFTRX2TS
Xfifo_to_fft_fifo_cell7_reg_gtok_token_reg
+ fifo_to_fft_fifo_cell7_reg_gtok_token clk__L1_N0 n5493 DFFQX1TS
Xfifo_to_fft_fifo_cell8_reg_gtok_token_reg
+ fifo_to_fft_fifo_cell8_reg_gtok_token clk__L1_N0 n5490 DFFQX1TS
Xfifo_to_fir_fifo_cell7_reg_gtok_token_reg
+ fifo_to_fir_fifo_cell7_reg_gtok_token clk__L1_N0 n5545 DFFQX1TS
Xfifo_to_fir_fifo_cell8_reg_gtok_token_reg
+ fifo_to_fir_fifo_cell8_reg_gtok_token clk__L1_N0 n5542 DFFQX1TS
Xfifo_from_fft_fifo_cell11_reg_gtok_token_reg
+ fifo_from_fft_fifo_cell11_reg_gtok_token clk__L1_N0 n6220 DFFQX1TS
Xfifo_to_fft_fifo_cell8_controller_valid_read_reg
+ fifo_to_fft_fifo_cell8_controller_valid_read clk__L1_N0 n9518 DFFQX1TS
Xfifo_to_fft_fifo_cell9_controller_valid_read_reg
+ fifo_to_fft_fifo_cell9_controller_valid_read clk__L1_N0 n9518 DFFQX1TS
Xfifo_from_fft_fifo_cell12_controller_valid_read_reg
+ fifo_from_fft_fifo_cell12_controller_valid_read clk__L1_N0 n9523 DFFQX1TS
Xfifo_to_fir_fifo_cell8_controller_valid_read_reg
+ fifo_to_fir_fifo_cell8_controller_valid_read clk__L1_N0 n9526 DFFQX1TS
Xfifo_to_fir_fifo_cell9_controller_valid_read_reg
+ fifo_to_fir_fifo_cell9_controller_valid_read clk__L1_N0 n9526 DFFQX1TS
Xfifo_from_fir_fifo_cell12_controller_valid_read_reg
+ fifo_from_fir_fifo_cell12_controller_valid_read clk__L1_N0 n9531 DFFQX1TS
Xfifo_from_fir_fifo_cell12_reg_ptok_token_reg n4793 fifo_from_fir_hang[11]
+ clk__L1_N0 n4792 n4667 DFFTRX2TS
Xfifo_from_fft_fifo_cell12_reg_ptok_token_reg n4607 fifo_from_fft_hang[11]
+ clk__L1_N0 n4606 n4481 DFFTRX2TS
Xfifo_to_fft_fifo_cell8_reg_ptok_token_reg n3982 fifo_to_fft_hang[7] clk__L1_N0
+ n3981 n3866 DFFTRX2TS
Xfifo_to_fir_fifo_cell8_reg_ptok_token_reg n4157 fifo_to_fir_hang[7] clk__L1_N0
+ n4156 n4041 DFFTRX2TS
Xfifo_to_fft_fifo_cell6_reg_gtok_token_reg
+ fifo_to_fft_fifo_cell6_reg_gtok_token clk__L1_N0 n5496 DFFQX1TS
Xfifo_to_fir_fifo_cell6_reg_gtok_token_reg
+ fifo_to_fir_fifo_cell6_reg_gtok_token clk__L1_N0 n5548 DFFQX1TS
Xfifo_from_fir_fifo_cell11_reg_gtok_token_reg
+ fifo_from_fir_fifo_cell11_reg_gtok_token clk__L1_N0 n6749 DFFQX1TS
Xfifo_to_fft_fifo_cell7_controller_valid_read_reg
+ fifo_to_fft_fifo_cell7_controller_valid_read clk__L1_N0 n9517 DFFQX1TS
Xfifo_from_fft_fifo_cell11_controller_valid_read_reg
+ fifo_from_fft_fifo_cell11_controller_valid_read clk__L1_N0 n9522 DFFQX1TS
Xfifo_to_fir_fifo_cell7_controller_valid_read_reg
+ fifo_to_fir_fifo_cell7_controller_valid_read clk__L1_N0 n9525 DFFQX1TS
Xfifo_from_fir_fifo_cell11_reg_ptok_token_reg n4796 fifo_from_fir_hang[10]
+ clk__L1_N0 n4795 n4665 DFFTRX2TS
Xfifo_to_fft_fifo_cell6_reg_ptok_token_reg n3988 fifo_to_fft_hang[5] clk__L1_N0
+ n3987 n3862 DFFTRX2TS
Xfifo_to_fft_fifo_cell7_reg_ptok_token_reg n3985 fifo_to_fft_hang[6] clk__L1_N0
+ n3984 n3864 DFFTRX2TS
Xfifo_to_fir_fifo_cell6_reg_ptok_token_reg n4163 fifo_to_fir_hang[5] clk__L1_N0
+ n4162 n4037 DFFTRX2TS
Xfifo_to_fir_fifo_cell7_reg_ptok_token_reg n4160 fifo_to_fir_hang[6] clk__L1_N0
+ n4159 n4039 DFFTRX2TS
Xfifo_from_fft_fifo_cell11_reg_ptok_token_reg n4610 fifo_from_fft_hang[10]
+ clk__L1_N0 n4609 n4479 DFFTRX2TS
Xfifo_to_fft_fifo_cell5_reg_gtok_token_reg
+ fifo_to_fft_fifo_cell5_reg_gtok_token clk__L1_N0 n5499 DFFQX1TS
Xfifo_to_fir_fifo_cell5_reg_gtok_token_reg
+ fifo_to_fir_fifo_cell5_reg_gtok_token clk__L1_N0 n5551 DFFQX1TS
Xfifo_from_fir_fifo_cell10_reg_gtok_token_reg
+ fifo_from_fir_fifo_cell10_reg_gtok_token clk__L1_N0 n6750 DFFQX1TS
Xfifo_from_fft_fifo_cell10_reg_gtok_token_reg
+ fifo_from_fft_fifo_cell10_reg_gtok_token clk__L1_N0 n6221 DFFQX1TS
Xfifo_to_fft_fifo_cell5_controller_valid_read_reg
+ fifo_to_fft_fifo_cell5_controller_valid_read clk__L1_N0 n9517 DFFQX1TS
Xfifo_to_fft_fifo_cell6_controller_valid_read_reg
+ fifo_to_fft_fifo_cell6_controller_valid_read clk__L1_N0 n9517 DFFQX1TS
Xfifo_to_fir_fifo_cell5_controller_valid_read_reg
+ fifo_to_fir_fifo_cell5_controller_valid_read clk__L1_N0 n9525 DFFQX1TS
Xfifo_to_fir_fifo_cell6_controller_valid_read_reg
+ fifo_to_fir_fifo_cell6_controller_valid_read clk__L1_N0 n9525 DFFQX1TS
Xfifo_from_fir_fifo_cell11_controller_valid_read_reg
+ fifo_from_fir_fifo_cell11_controller_valid_read clk__L1_N0 n9529 DFFQX1TS
Xfifo_from_fir_fifo_cell10_reg_ptok_token_reg n4799 fifo_from_fir_hang[9]
+ clk__L1_N0 n4798 n4663 DFFTRX2TS
Xfifo_to_fft_fifo_cell5_reg_ptok_token_reg n3991 fifo_to_fft_hang[4] clk__L1_N0
+ n3990 n3860 DFFTRX2TS
Xfifo_to_fir_fifo_cell5_reg_ptok_token_reg n4166 fifo_to_fir_hang[4] clk__L1_N0
+ n4165 n4035 DFFTRX2TS
Xfifo_from_fft_fifo_cell10_reg_ptok_token_reg n4613 fifo_from_fft_hang[9]
+ clk__L1_N0 n4612 n4477 DFFTRX2TS
Xfifo_to_fft_fifo_cell3_reg_gtok_token_reg
+ fifo_to_fft_fifo_cell3_reg_gtok_token clk__L1_N0 n5505 DFFQX1TS
Xfifo_to_fft_fifo_cell4_reg_gtok_token_reg
+ fifo_to_fft_fifo_cell4_reg_gtok_token clk__L1_N0 n5502 DFFQX1TS
Xfifo_to_fir_fifo_cell3_reg_gtok_token_reg
+ fifo_to_fir_fifo_cell3_reg_gtok_token clk__L1_N0 n5557 DFFQX1TS
Xfifo_to_fir_fifo_cell4_reg_gtok_token_reg
+ fifo_to_fir_fifo_cell4_reg_gtok_token clk__L1_N0 n5554 DFFQX1TS
Xfifo_from_fir_fifo_cell9_reg_gtok_token_reg
+ fifo_from_fir_fifo_cell9_reg_gtok_token clk__L1_N0 n6751 DFFQX1TS
Xfifo_from_fft_fifo_cell9_reg_gtok_token_reg
+ fifo_from_fft_fifo_cell9_reg_gtok_token clk__L1_N0 n6222 DFFQX1TS
Xfifo_to_fft_fifo_cell4_controller_valid_read_reg
+ fifo_to_fft_fifo_cell4_controller_valid_read clk__L1_N0 n9517 DFFQX1TS
Xfifo_from_fft_fifo_cell10_controller_valid_read_reg
+ fifo_from_fft_fifo_cell10_controller_valid_read clk__L1_N0 n9522 DFFQX1TS
Xfifo_to_fir_fifo_cell4_controller_valid_read_reg
+ fifo_to_fir_fifo_cell4_controller_valid_read clk__L1_N0 n9525 DFFQX1TS
Xfifo_from_fir_fifo_cell10_controller_valid_read_reg
+ fifo_from_fir_fifo_cell10_controller_valid_read clk__L1_N0 n9531 DFFQX1TS
Xfifo_to_fft_fifo_cell4_reg_ptok_token_reg n3994 fifo_to_fft_hang[3] clk__L1_N0
+ n3993 n3858 DFFTRX2TS
Xfifo_to_fir_fifo_cell4_reg_ptok_token_reg n4169 fifo_to_fir_hang[3] clk__L1_N0
+ n4168 n4033 DFFTRX2TS
Xfifo_to_fft_fifo_cell2_reg_gtok_token_reg
+ fifo_to_fft_fifo_cell2_reg_gtok_token clk__L1_N0 n5508 DFFQX1TS
Xfifo_to_fir_fifo_cell2_reg_gtok_token_reg
+ fifo_to_fir_fifo_cell2_reg_gtok_token clk__L1_N0 n5560 DFFQX1TS
Xfifo_from_fir_fifo_cell8_reg_gtok_token_reg
+ fifo_from_fir_fifo_cell8_reg_gtok_token clk__L1_N0 n6752 DFFQX1TS
Xfifo_from_fft_fifo_cell8_reg_gtok_token_reg
+ fifo_from_fft_fifo_cell8_reg_gtok_token clk__L1_N0 n6223 DFFQX1TS
Xfifo_to_fft_fifo_cell3_controller_valid_read_reg
+ fifo_to_fft_fifo_cell3_controller_valid_read clk__L1_N0 n9516 DFFQX1TS
Xfifo_from_fft_fifo_cell9_controller_valid_read_reg
+ fifo_from_fft_fifo_cell9_controller_valid_read clk__L1_N0 n9522 DFFQX1TS
Xfifo_to_fir_fifo_cell3_controller_valid_read_reg
+ fifo_to_fir_fifo_cell3_controller_valid_read clk__L1_N0 n9524 DFFQX1TS
Xfifo_from_fir_fifo_cell9_controller_valid_read_reg
+ fifo_from_fir_fifo_cell9_controller_valid_read clk__L1_N0 n9529 DFFQX1TS
Xfifo_from_fir_fifo_cell9_reg_ptok_token_reg n4802 fifo_from_fir_hang[8]
+ clk__L1_N0 n4801 n4661 DFFTRX2TS
Xfifo_to_fft_fifo_cell2_reg_ptok_token_reg n4000 fifo_to_fft_hang[1] clk__L1_N0
+ n3999 n3854 DFFTRX2TS
Xfifo_to_fft_fifo_cell3_reg_ptok_token_reg n3997 fifo_to_fft_hang[2] clk__L1_N0
+ n3996 n3856 DFFTRX2TS
Xfifo_to_fir_fifo_cell2_reg_ptok_token_reg n4175 fifo_to_fir_hang[1] clk__L1_N0
+ n4174 n4029 DFFTRX2TS
Xfifo_to_fir_fifo_cell3_reg_ptok_token_reg n4172 fifo_to_fir_hang[2] clk__L1_N0
+ n4171 n4031 DFFTRX2TS
Xfifo_from_fft_fifo_cell9_reg_ptok_token_reg n4616 fifo_from_fft_hang[8]
+ clk__L1_N0 n4615 n4475 DFFTRX2TS
Xrouter_data_cntl_fir_put_req_reg router_fir_put_req_reg clk__L1_N0 n5459
+ DFFQX1TS
Xfifo_to_fft_fifo_cell1_reg_gtok_token_reg
+ fifo_to_fft_fifo_cell1_reg_gtok_token clk__L1_N0 n5511 DFFQX1TS
Xfifo_to_fir_fifo_cell1_reg_gtok_token_reg
+ fifo_to_fir_fifo_cell1_reg_gtok_token clk__L1_N0 n5563 DFFQX1TS
Xfifo_to_fft_fifo_cell1_controller_valid_read_reg
+ fifo_to_fft_fifo_cell1_controller_valid_read clk__L1_N0 n9519 DFFQX1TS
Xfifo_to_fir_fifo_cell1_controller_valid_read_reg
+ fifo_to_fir_fifo_cell1_controller_valid_read clk__L1_N0 n9524 DFFQX1TS
Xfifo_to_fft_fifo_cell1_reg_ptok_token_reg fifo_to_fft_hang[0] clk__L1_N0 n5517
+ DFFQX1TS
Xfifo_to_fir_fifo_cell1_reg_ptok_token_reg fifo_to_fir_hang[0] clk__L1_N0 n5569
+ DFFQX1TS
Xfifo_to_fft_fifo_cell2_controller_valid_read_reg
+ fifo_to_fft_fifo_cell2_controller_valid_read clk__L1_N0 n9516 DFFQX1TS
Xfifo_to_fir_fifo_cell2_controller_valid_read_reg
+ fifo_to_fir_fifo_cell2_controller_valid_read clk__L1_N0 n9524 DFFQX1TS
Xrouter_data_cntl_fft_put_req_reg 1192 router_fft_put_req_reg clk__L1_N0 n7611
+ n3831 n2848 EDFFTRX1TS
Xfifo_to_fft_fifo_cell0_controller_f_i_get_reg
+ fifo_to_fft_fifo_cell0_controller_f_i_get clk__L1_N0 n5456 DFFQX1TS
Xfifo_to_fft_fifo_cell15_controller_f_i_get_reg
+ fifo_to_fft_fifo_cell15_controller_f_i_get clk__L1_N0 n5471 DFFQX1TS
Xfifo_to_fft_fifo_cell14_controller_f_i_get_reg
+ fifo_to_fft_fifo_cell14_controller_f_i_get clk__L1_N0 n5474 DFFQX1TS
Xfifo_to_fft_fifo_cell13_controller_f_i_get_reg
+ fifo_to_fft_fifo_cell13_controller_f_i_get clk__L1_N0 n5477 DFFQX1TS
Xfifo_to_fft_fifo_cell12_controller_f_i_get_reg
+ fifo_to_fft_fifo_cell12_controller_f_i_get clk__L1_N0 n5480 DFFQX1TS
Xfifo_to_fft_fifo_cell11_controller_f_i_get_reg
+ fifo_to_fft_fifo_cell11_controller_f_i_get clk__L1_N0 n5483 DFFQX1TS
Xfifo_to_fft_fifo_cell10_controller_f_i_get_reg
+ fifo_to_fft_fifo_cell10_controller_f_i_get clk__L1_N0 n5486 DFFQX1TS
Xfifo_to_fft_fifo_cell9_controller_f_i_get_reg
+ fifo_to_fft_fifo_cell9_controller_f_i_get clk__L1_N0 n5489 DFFQX1TS
Xfifo_to_fft_fifo_cell8_controller_f_i_get_reg
+ fifo_to_fft_fifo_cell8_controller_f_i_get clk__L1_N0 n5492 DFFQX1TS
Xfifo_to_fft_fifo_cell7_controller_f_i_get_reg
+ fifo_to_fft_fifo_cell7_controller_f_i_get clk__L1_N0 n5495 DFFQX1TS
Xfifo_to_fft_fifo_cell6_controller_f_i_get_reg
+ fifo_to_fft_fifo_cell6_controller_f_i_get clk__L1_N0 n5498 DFFQX1TS
Xfifo_to_fft_fifo_cell5_controller_f_i_get_reg
+ fifo_to_fft_fifo_cell5_controller_f_i_get clk__L1_N0 n5501 DFFQX1TS
Xfifo_to_fft_fifo_cell4_controller_f_i_get_reg
+ fifo_to_fft_fifo_cell4_controller_f_i_get clk__L1_N0 n5504 DFFQX1TS
Xfifo_to_fft_fifo_cell3_controller_f_i_get_reg
+ fifo_to_fft_fifo_cell3_controller_f_i_get clk__L1_N0 n5507 DFFQX1TS
Xfifo_to_fft_fifo_cell2_controller_f_i_get_reg
+ fifo_to_fft_fifo_cell2_controller_f_i_get clk__L1_N0 n5510 DFFQX1TS
Xfifo_to_fft_fifo_cell1_controller_f_i_get_reg
+ fifo_to_fft_fifo_cell1_controller_f_i_get clk__L1_N0 n5513 DFFQX1TS
Xfifo_to_fir_fifo_cell0_controller_f_i_get_reg
+ fifo_to_fir_fifo_cell0_controller_f_i_get clk__L1_N0 n5454 DFFQX1TS
Xfifo_to_fir_fifo_cell1_controller_f_i_get_reg
+ fifo_to_fir_fifo_cell1_controller_f_i_get clk__L1_N0 n5565 DFFQX1TS
Xfifo_to_fft_fifo_cell0_reg_gtok_token_reg
+ fifo_to_fft_fifo_cell0_reg_gtok_token clk__L1_N0 n5514 DFFQX1TS
Xfifo_to_fir_fifo_cell0_reg_gtok_token_reg
+ fifo_to_fir_fifo_cell0_reg_gtok_token clk__L1_N0 n5566 DFFQX1TS
Xfifo_from_fir_fifo_cell7_reg_gtok_token_reg
+ fifo_from_fir_fifo_cell7_reg_gtok_token clk__L1_N0 n6753 DFFQX1TS
Xfifo_from_fft_fifo_cell7_reg_gtok_token_reg
+ fifo_from_fft_fifo_cell7_reg_gtok_token clk__L1_N0 n6224 DFFQX1TS
Xfifo_to_fft_fifo_cell0_controller_f_i_put_reg
+ fifo_to_fft_fifo_cell0_controller_f_i_put clk__L1_N0 n5515 DFFQX1TS
Xfifo_to_fft_fifo_cell14_controller_f_i_put_reg
+ fifo_to_fft_fifo_cell14_controller_f_i_put clk__L1_N0 n5473 DFFQX1TS
Xfifo_to_fft_fifo_cell13_controller_f_i_put_reg
+ fifo_to_fft_fifo_cell13_controller_f_i_put clk__L1_N0 n5476 DFFQX1TS
Xfifo_to_fft_fifo_cell12_controller_f_i_put_reg
+ fifo_to_fft_fifo_cell12_controller_f_i_put clk__L1_N0 n5479 DFFQX1TS
Xfifo_to_fft_fifo_cell10_controller_f_i_put_reg
+ fifo_to_fft_fifo_cell10_controller_f_i_put clk__L1_N0 n5485 DFFQX1TS
Xfifo_to_fft_fifo_cell9_controller_f_i_put_reg
+ fifo_to_fft_fifo_cell9_controller_f_i_put clk__L1_N0 n5488 DFFQX1TS
Xfifo_to_fft_fifo_cell8_controller_f_i_put_reg
+ fifo_to_fft_fifo_cell8_controller_f_i_put clk__L1_N0 n5491 DFFQX1TS
Xfifo_to_fft_fifo_cell6_controller_f_i_put_reg
+ fifo_to_fft_fifo_cell6_controller_f_i_put clk__L1_N0 n5497 DFFQX1TS
Xfifo_to_fft_fifo_cell5_controller_f_i_put_reg
+ fifo_to_fft_fifo_cell5_controller_f_i_put clk__L1_N0 n5500 DFFQX1TS
Xfifo_to_fft_fifo_cell4_controller_f_i_put_reg
+ fifo_to_fft_fifo_cell4_controller_f_i_put clk__L1_N0 n5503 DFFQX1TS
Xfifo_to_fft_fifo_cell3_controller_f_i_put_reg
+ fifo_to_fft_fifo_cell3_controller_f_i_put clk__L1_N0 n5506 DFFQX1TS
Xfifo_to_fft_fifo_cell2_controller_f_i_put_reg
+ fifo_to_fft_fifo_cell2_controller_f_i_put clk__L1_N0 n5509 DFFQX1TS
Xfifo_to_fft_fifo_cell1_controller_f_i_put_reg
+ fifo_to_fft_fifo_cell1_controller_f_i_put clk__L1_N0 n5512 DFFQX1TS
Xfifo_from_fft_fifo_cell8_controller_valid_read_reg
+ fifo_from_fft_fifo_cell8_controller_valid_read clk__L1_N0 n9522 DFFQX1TS
Xfifo_from_fir_fifo_cell8_controller_valid_read_reg
+ fifo_from_fir_fifo_cell8_controller_valid_read clk__L1_N0 n9530 DFFQX1TS
Xfifo_from_fir_fifo_cell8_reg_ptok_token_reg n4805 fifo_from_fir_hang[7]
+ clk__L1_N0 n4804 n4659 DFFTRX2TS
Xfifo_from_fft_fifo_cell8_reg_ptok_token_reg n4619 fifo_from_fft_hang[7]
+ clk__L1_N0 n4618 n4473 DFFTRX2TS
Xfifo_to_fir_fifo_cell15_controller_f_i_get_reg
+ fifo_to_fir_fifo_cell15_controller_f_i_get clk__L1_N0 n5523 DFFQX1TS
Xfifo_to_fir_fifo_cell14_controller_f_i_get_reg
+ fifo_to_fir_fifo_cell14_controller_f_i_get clk__L1_N0 n5526 DFFQX1TS
Xfifo_to_fir_fifo_cell13_controller_f_i_get_reg
+ fifo_to_fir_fifo_cell13_controller_f_i_get clk__L1_N0 n5529 DFFQX1TS
Xfifo_to_fir_fifo_cell12_controller_f_i_get_reg
+ fifo_to_fir_fifo_cell12_controller_f_i_get clk__L1_N0 n5532 DFFQX1TS
Xfifo_to_fir_fifo_cell11_controller_f_i_get_reg
+ fifo_to_fir_fifo_cell11_controller_f_i_get clk__L1_N0 n5535 DFFQX1TS
Xfifo_to_fir_fifo_cell10_controller_f_i_get_reg
+ fifo_to_fir_fifo_cell10_controller_f_i_get clk__L1_N0 n5538 DFFQX1TS
Xfifo_to_fir_fifo_cell9_controller_f_i_get_reg
+ fifo_to_fir_fifo_cell9_controller_f_i_get clk__L1_N0 n5541 DFFQX1TS
Xfifo_to_fir_fifo_cell8_controller_f_i_get_reg
+ fifo_to_fir_fifo_cell8_controller_f_i_get clk__L1_N0 n5544 DFFQX1TS
Xfifo_to_fir_fifo_cell7_controller_f_i_get_reg
+ fifo_to_fir_fifo_cell7_controller_f_i_get clk__L1_N0 n5547 DFFQX1TS
Xfifo_to_fir_fifo_cell6_controller_f_i_get_reg
+ fifo_to_fir_fifo_cell6_controller_f_i_get clk__L1_N0 n5550 DFFQX1TS
Xfifo_to_fir_fifo_cell5_controller_f_i_get_reg
+ fifo_to_fir_fifo_cell5_controller_f_i_get clk__L1_N0 n5553 DFFQX1TS
Xfifo_to_fir_fifo_cell4_controller_f_i_get_reg
+ fifo_to_fir_fifo_cell4_controller_f_i_get clk__L1_N0 n5556 DFFQX1TS
Xfifo_to_fir_fifo_cell3_controller_f_i_get_reg
+ fifo_to_fir_fifo_cell3_controller_f_i_get clk__L1_N0 n5559 DFFQX1TS
Xfifo_to_fir_fifo_cell2_controller_f_i_get_reg
+ fifo_to_fir_fifo_cell2_controller_f_i_get clk__L1_N0 n5562 DFFQX1TS
Xfifo_to_fft_fifo_cell15_controller_f_i_put_reg
+ fifo_to_fft_fifo_cell15_controller_f_i_put clk__L1_N0 n5470 DFFQX1TS
Xfifo_to_fft_fifo_cell11_controller_f_i_put_reg
+ fifo_to_fft_fifo_cell11_controller_f_i_put clk__L1_N0 n5482 DFFQX1TS
Xfifo_to_fft_fifo_cell7_controller_f_i_put_reg
+ fifo_to_fft_fifo_cell7_controller_f_i_put clk__L1_N0 n5494 DFFQX1TS
Xfifo_to_fir_fifo_cell0_controller_f_i_put_reg
+ fifo_to_fir_fifo_cell0_controller_f_i_put clk__L1_N0 n5567 DFFQX1TS
Xfifo_to_fir_fifo_cell15_controller_f_i_put_reg
+ fifo_to_fir_fifo_cell15_controller_f_i_put clk__L1_N0 n5522 DFFQX1TS
Xfifo_to_fir_fifo_cell14_controller_f_i_put_reg
+ fifo_to_fir_fifo_cell14_controller_f_i_put clk__L1_N0 n5525 DFFQX1TS
Xfifo_to_fir_fifo_cell13_controller_f_i_put_reg
+ fifo_to_fir_fifo_cell13_controller_f_i_put clk__L1_N0 n5528 DFFQX1TS
Xfifo_to_fir_fifo_cell12_controller_f_i_put_reg
+ fifo_to_fir_fifo_cell12_controller_f_i_put clk__L1_N0 n5531 DFFQX1TS
Xfifo_to_fir_fifo_cell11_controller_f_i_put_reg
+ fifo_to_fir_fifo_cell11_controller_f_i_put clk__L1_N0 n5534 DFFQX1TS
Xfifo_to_fir_fifo_cell10_controller_f_i_put_reg
+ fifo_to_fir_fifo_cell10_controller_f_i_put clk__L1_N0 n5537 DFFQX1TS
Xfifo_to_fir_fifo_cell9_controller_f_i_put_reg
+ fifo_to_fir_fifo_cell9_controller_f_i_put clk__L1_N0 n5540 DFFQX1TS
Xfifo_to_fir_fifo_cell8_controller_f_i_put_reg
+ fifo_to_fir_fifo_cell8_controller_f_i_put clk__L1_N0 n5543 DFFQX1TS
Xfifo_to_fir_fifo_cell7_controller_f_i_put_reg
+ fifo_to_fir_fifo_cell7_controller_f_i_put clk__L1_N0 n5546 DFFQX1TS
Xfifo_to_fir_fifo_cell6_controller_f_i_put_reg
+ fifo_to_fir_fifo_cell6_controller_f_i_put clk__L1_N0 n5549 DFFQX1TS
Xfifo_to_fir_fifo_cell5_controller_f_i_put_reg
+ fifo_to_fir_fifo_cell5_controller_f_i_put clk__L1_N0 n5552 DFFQX1TS
Xfifo_to_fir_fifo_cell4_controller_f_i_put_reg
+ fifo_to_fir_fifo_cell4_controller_f_i_put clk__L1_N0 n5555 DFFQX1TS
Xfifo_to_fir_fifo_cell3_controller_f_i_put_reg
+ fifo_to_fir_fifo_cell3_controller_f_i_put clk__L1_N0 n5558 DFFQX1TS
Xfifo_to_fir_fifo_cell2_controller_f_i_put_reg
+ fifo_to_fir_fifo_cell2_controller_f_i_put clk__L1_N0 n5561 DFFQX1TS
Xfifo_to_fir_fifo_cell1_controller_f_i_put_reg
+ fifo_to_fir_fifo_cell1_controller_f_i_put clk__L1_N0 n5564 DFFQX1TS
Xfifo_from_fft_fifo_cell7_controller_valid_read_reg
+ fifo_from_fft_fifo_cell7_controller_valid_read clk__L1_N0 n9521 DFFQX1TS
Xfifo_from_fir_fifo_cell7_controller_valid_read_reg
+ fifo_from_fir_fifo_cell7_controller_valid_read clk__L1_N0 n9530 DFFQX1TS
Xfifo_from_fir_fifo_cell7_reg_ptok_token_reg n4808 fifo_from_fir_hang[6]
+ clk__L1_N0 n4807 n4657 DFFTRX2TS
Xfifo_from_fft_fifo_cell7_reg_ptok_token_reg n4622 fifo_from_fft_hang[6]
+ clk__L1_N0 n4621 n4471 DFFTRX2TS
Xfifo_from_fir_fifo_cell6_reg_gtok_token_reg
+ fifo_from_fir_fifo_cell6_reg_gtok_token clk__L1_N0 n6754 DFFQX1TS
Xfifo_from_fft_fifo_cell6_reg_gtok_token_reg
+ fifo_from_fft_fifo_cell6_reg_gtok_token clk__L1_N0 n6225 DFFQX1TS
Xfifo_to_fft_empty_det_result_reg to_fft_empty clk__L1_N0
+ fifo_to_fft_empty_det_N4 DFFQX4TS
Xfifo_to_fir_empty_det_result_reg to_fir_empty clk__L1_N0
+ fifo_to_fir_empty_det_N4 DFFQX4TS
Xfifo_from_fir_fifo_cell6_reg_ptok_token_reg n4811 fifo_from_fir_hang[5]
+ clk__L1_N0 n4810 n4655 DFFTRX2TS
Xfifo_from_fft_fifo_cell6_reg_ptok_token_reg n4625 fifo_from_fft_hang[5]
+ clk__L1_N0 n4624 n4469 DFFTRX2TS
Xfifo_from_fir_fifo_cell5_reg_gtok_token_reg
+ fifo_from_fir_fifo_cell5_reg_gtok_token clk__L1_N0 n6755 DFFQX1TS
Xfifo_from_fft_fifo_cell5_reg_gtok_token_reg
+ fifo_from_fft_fifo_cell5_reg_gtok_token clk__L1_N0 n6226 DFFQX1TS
Xfifo_from_fft_fifo_cell6_controller_valid_read_reg
+ fifo_from_fft_fifo_cell6_controller_valid_read clk__L1_N0 n9521 DFFQX1TS
Xfifo_from_fir_fifo_cell6_controller_valid_read_reg
+ fifo_from_fir_fifo_cell6_controller_valid_read clk__L1_N0 n9529 DFFQX1TS
Xfifo_from_fir_fifo_cell4_reg_gtok_token_reg
+ fifo_from_fir_fifo_cell4_reg_gtok_token clk__L1_N0 n6756 DFFQX1TS
Xfifo_from_fft_fifo_cell4_reg_gtok_token_reg
+ fifo_from_fft_fifo_cell4_reg_gtok_token clk__L1_N0 n6227 DFFQX1TS
Xfifo_from_fft_fifo_cell5_controller_valid_read_reg
+ fifo_from_fft_fifo_cell5_controller_valid_read clk__L1_N0 n9521 DFFQX1TS
Xfifo_from_fir_fifo_cell5_controller_valid_read_reg
+ fifo_from_fir_fifo_cell5_controller_valid_read clk__L1_N0 n9530 DFFQX1TS
Xfifo_from_fir_fifo_cell5_reg_ptok_token_reg n4814 fifo_from_fir_hang[4]
+ clk__L1_N0 n4813 n4653 DFFTRX2TS
Xfifo_from_fft_fifo_cell5_reg_ptok_token_reg n4628 fifo_from_fft_hang[4]
+ clk__L1_N0 n4627 n4467 DFFTRX2TS
Xfifo_from_fir_fifo_cell3_reg_gtok_token_reg
+ fifo_from_fir_fifo_cell3_reg_gtok_token clk__L1_N0 n6757 DFFQX1TS
Xfifo_from_fft_fifo_cell3_reg_gtok_token_reg
+ fifo_from_fft_fifo_cell3_reg_gtok_token clk__L1_N0 n6228 DFFQX1TS
Xfifo_from_fft_fifo_cell4_controller_valid_read_reg
+ fifo_from_fft_fifo_cell4_controller_valid_read clk__L1_N0 n9521 DFFQX1TS
Xfifo_from_fir_fifo_cell4_controller_valid_read_reg
+ fifo_from_fir_fifo_cell4_controller_valid_read clk__L1_N0 n9530 DFFQX1TS
Xfifo_from_fir_fifo_cell4_reg_ptok_token_reg n4817 fifo_from_fir_hang[3]
+ clk__L1_N0 n4816 n4651 DFFTRX2TS
Xfifo_from_fft_fifo_cell4_reg_ptok_token_reg n4631 fifo_from_fft_hang[3]
+ clk__L1_N0 n4630 n4465 DFFTRX2TS
Xfifo_from_fft_fifo_cell3_controller_valid_read_reg
+ fifo_from_fft_fifo_cell3_controller_valid_read clk__L1_N0 n9520 DFFQX1TS
Xfifo_from_fir_fifo_cell3_controller_valid_read_reg
+ fifo_from_fir_fifo_cell3_controller_valid_read clk__L1_N0 n9528 DFFQX1TS
Xfifo_from_fir_fifo_cell3_reg_ptok_token_reg n4820 fifo_from_fir_hang[2]
+ clk__L1_N0 n4819 n4649 DFFTRX2TS
Xfifo_from_fft_fifo_cell3_reg_ptok_token_reg n4634 fifo_from_fft_hang[2]
+ clk__L1_N0 n4633 n4463 DFFTRX2TS
Xfifo_from_fir_fifo_cell2_reg_gtok_token_reg
+ fifo_from_fir_fifo_cell2_reg_gtok_token clk__L1_N0 n6758 DFFQX1TS
Xfifo_from_fft_fifo_cell2_reg_gtok_token_reg
+ fifo_from_fft_fifo_cell2_reg_gtok_token clk__L1_N0 n6229 DFFQX1TS
Xfifo_from_fir_fifo_cell2_reg_ptok_token_reg n4823 fifo_from_fir_hang[1]
+ clk__L1_N0 n4822 n4647 DFFTRX2TS
Xfifo_from_fir_fifo_cell1_reg_gtok_token_reg
+ fifo_from_fir_fifo_cell1_reg_gtok_token clk__L1_N0 n6759 DFFQX1TS
Xfifo_from_fft_fifo_cell1_reg_gtok_token_reg
+ fifo_from_fft_fifo_cell1_reg_gtok_token clk__L1_N0 n6230 DFFQX1TS
Xfifo_from_fft_fifo_cell2_controller_valid_read_reg
+ fifo_from_fft_fifo_cell2_controller_valid_read clk__L1_N0 n9520 DFFQX1TS
Xfifo_from_fir_fifo_cell2_controller_valid_read_reg
+ fifo_from_fir_fifo_cell2_controller_valid_read clk__L1_N0 n9528 DFFQX1TS
Xfifo_from_fft_fifo_cell2_reg_ptok_token_reg n4637 fifo_from_fft_hang[1]
+ clk__L1_N0 n4636 n4461 DFFTRX2TS
Xfifo_from_fir_fifo_cell0_reg_gtok_token_reg
+ fifo_from_fir_fifo_cell0_reg_gtok_token clk__L1_N0 n6760 DFFQX1TS
Xfifo_from_fft_fifo_cell1_controller_valid_read_reg
+ fifo_from_fft_fifo_cell1_controller_valid_read clk__L1_N0 n9520 DFFQX1TS
Xfifo_from_fir_fifo_cell1_controller_valid_read_reg
+ fifo_from_fir_fifo_cell1_controller_valid_read clk__L1_N0 n9528 DFFQX1TS
Xfifo_from_fir_fifo_cell1_reg_ptok_token_reg n4826 fifo_from_fir_hang[0]
+ clk__L1_N0 n4825 n4645 DFFTRX2TS
Xfifo_from_fft_fifo_cell1_reg_ptok_token_reg n4640 fifo_from_fft_hang[0]
+ clk__L1_N0 n4639 n4459 DFFTRX2TS
Xrouter_data_cntl_fir_get_req_reg router_fir_get_req_reg clk__L1_N0 n6761
+ DFFQX1TS
Xfifo_from_fft_fifo_cell0_reg_gtok_token_reg
+ fifo_from_fft_fifo_cell0_reg_gtok_token clk__L1_N0 n6231 DFFQX1TS
Xrouter_pla_top_fir_enable_reg n9615 clk__L1_N0 n5573 DFFQX1TS
Xrouter_addr_calc_fir_read_calc_counter_done_reg router_fir_read_done
+ clk__L1_N0 n5571 DFFQX1TS
Xrouter_addr_calc_fir_write_calc_counter_done_reg router_fir_write_done
+ clk__L1_N0 n5519 DFFQX1TS
Xrouter_addr_calc_fft_write_calc_counter_done_reg router_fft_write_done
+ clk__L1_N0 FE_OFN961_n5467 DFFQX1TS
Xrouter_addr_calc_fft_read_calc_counter_done_reg router_fft_read_done
+ clk__L1_N0 n5704 DFFQX1TS
Xrouter_data_cntl_fft_get_req_reg router_fft_get_req_reg clk__L1_N0 n6232
+ DFFQX1TS
Xfifo_from_fir_fifo_cell0_controller_f_i_get_reg
+ fifo_from_fir_fifo_cell0_controller_f_i_get clk__L1_N0 n5417 DFFQX1TS
Xfifo_from_fir_fifo_cell1_controller_f_i_get_reg
+ fifo_from_fir_fifo_cell1_controller_f_i_get clk__L1_N0 n6742 DFFQX1TS
Xfifo_from_fir_fifo_cell2_controller_f_i_get_reg
+ fifo_from_fir_fifo_cell2_controller_f_i_get clk__L1_N0 n6708 DFFQX1TS
Xfifo_from_fir_fifo_cell3_controller_f_i_get_reg
+ fifo_from_fir_fifo_cell3_controller_f_i_get clk__L1_N0 n6674 DFFQX1TS
Xfifo_from_fir_fifo_cell4_controller_f_i_get_reg
+ fifo_from_fir_fifo_cell4_controller_f_i_get clk__L1_N0 n6640 DFFQX1TS
Xfifo_from_fir_fifo_cell5_controller_f_i_get_reg
+ fifo_from_fir_fifo_cell5_controller_f_i_get clk__L1_N0 n6606 DFFQX1TS
Xfifo_from_fir_fifo_cell6_controller_f_i_get_reg
+ fifo_from_fir_fifo_cell6_controller_f_i_get clk__L1_N0 n6572 DFFQX1TS
Xfifo_from_fir_fifo_cell7_controller_f_i_get_reg
+ fifo_from_fir_fifo_cell7_controller_f_i_get clk__L1_N0 n6538 DFFQX1TS
Xfifo_from_fir_fifo_cell8_controller_f_i_get_reg
+ fifo_from_fir_fifo_cell8_controller_f_i_get clk__L1_N0 n6504 DFFQX1TS
Xfifo_from_fir_fifo_cell9_controller_f_i_get_reg
+ fifo_from_fir_fifo_cell9_controller_f_i_get clk__L1_N0 n6470 DFFQX1TS
Xfifo_from_fir_fifo_cell10_controller_f_i_get_reg
+ fifo_from_fir_fifo_cell10_controller_f_i_get clk__L1_N0 n6436 DFFQX1TS
Xfifo_from_fir_fifo_cell11_controller_f_i_get_reg
+ fifo_from_fir_fifo_cell11_controller_f_i_get clk__L1_N0 n6402 DFFQX1TS
Xfifo_from_fir_fifo_cell12_controller_f_i_get_reg
+ fifo_from_fir_fifo_cell12_controller_f_i_get clk__L1_N0 n6368 DFFQX1TS
Xfifo_from_fir_fifo_cell13_controller_f_i_get_reg
+ fifo_from_fir_fifo_cell13_controller_f_i_get clk__L1_N0 n6334 DFFQX1TS
Xfifo_from_fir_fifo_cell14_controller_f_i_get_reg
+ fifo_from_fir_fifo_cell14_controller_f_i_get clk__L1_N0 n6300 DFFQX1TS
Xfifo_from_fir_fifo_cell15_controller_f_i_get_reg
+ fifo_from_fir_fifo_cell15_controller_f_i_get clk__L1_N0 n6266 DFFQX1TS
Xrouter_pla_top_fft_enable_reg n9614 clk__L1_N0 n5466 DFFQX1TS
Xfifo_from_fir_fifo_cell0_controller_f_i_put_reg
+ fifo_from_fir_fifo_cell0_controller_f_i_put clk__L1_N0 n6744 DFFQX1TS
Xfifo_from_fir_fifo_cell1_controller_f_i_put_reg
+ fifo_from_fir_fifo_cell1_controller_f_i_put clk__L1_N0 n6743 DFFQX1TS
Xfifo_from_fir_fifo_cell2_controller_f_i_put_reg
+ fifo_from_fir_fifo_cell2_controller_f_i_put clk__L1_N0 n6709 DFFQX1TS
Xfifo_from_fir_fifo_cell3_controller_f_i_put_reg
+ fifo_from_fir_fifo_cell3_controller_f_i_put clk__L1_N0 n6675 DFFQX1TS
Xfifo_from_fir_fifo_cell4_controller_f_i_put_reg
+ fifo_from_fir_fifo_cell4_controller_f_i_put clk__L1_N0 n6641 DFFQX1TS
Xfifo_from_fir_fifo_cell5_controller_f_i_put_reg
+ fifo_from_fir_fifo_cell5_controller_f_i_put clk__L1_N0 n6607 DFFQX1TS
Xfifo_from_fir_fifo_cell6_controller_f_i_put_reg
+ fifo_from_fir_fifo_cell6_controller_f_i_put clk__L1_N0 n6573 DFFQX1TS
Xfifo_from_fir_fifo_cell7_controller_f_i_put_reg
+ fifo_from_fir_fifo_cell7_controller_f_i_put clk__L1_N0 n6539 DFFQX1TS
Xfifo_from_fir_fifo_cell8_controller_f_i_put_reg
+ fifo_from_fir_fifo_cell8_controller_f_i_put clk__L1_N0 n6505 DFFQX1TS
Xfifo_from_fir_fifo_cell9_controller_f_i_put_reg
+ fifo_from_fir_fifo_cell9_controller_f_i_put clk__L1_N0 n6471 DFFQX1TS
Xfifo_from_fir_fifo_cell10_controller_f_i_put_reg
+ fifo_from_fir_fifo_cell10_controller_f_i_put clk__L1_N0 n6437 DFFQX1TS
Xfifo_from_fir_fifo_cell11_controller_f_i_put_reg
+ fifo_from_fir_fifo_cell11_controller_f_i_put clk__L1_N0 n6403 DFFQX1TS
Xfifo_from_fir_fifo_cell12_controller_f_i_put_reg
+ fifo_from_fir_fifo_cell12_controller_f_i_put clk__L1_N0 n6369 DFFQX1TS
Xfifo_from_fir_fifo_cell13_controller_f_i_put_reg
+ fifo_from_fir_fifo_cell13_controller_f_i_put clk__L1_N0 n6335 DFFQX1TS
Xfifo_from_fir_fifo_cell14_controller_f_i_put_reg
+ fifo_from_fir_fifo_cell14_controller_f_i_put clk__L1_N0 n6301 DFFQX1TS
Xfifo_from_fir_fifo_cell15_controller_f_i_put_reg
+ fifo_from_fir_fifo_cell15_controller_f_i_put clk__L1_N0 n6267 DFFQX1TS
Xmips_mips_c_md_accfullinstruction_reg[31] mips_mips_accfullinstruction[31]
+ 1193 clk__L1_N0 n5574 VDD VDD DFFNSRX2TS
Xmips_mips_c_md_accfullinstruction_reg[30] mips_mips_accfullinstruction[30]
+ 1194 clk__L1_N0 n5575 VDD VDD DFFNSRX2TS
Xmips_mips_c_md_accfullinstruction_reg[29] mips_mips_accfullinstruction[29]
+ 1195 clk__L1_N0 n5576 VDD VDD DFFNSRX2TS
Xmips_mips_c_md_accfullinstruction_reg[28] mips_mips_accfullinstruction[28]
+ 1196 clk__L1_N0 n5577 VDD VDD DFFNSRX2TS
Xmips_mips_c_md_accfullinstruction_reg[27] mips_mips_accfullinstruction[27]
+ 1197 clk__L1_N0 n5578 VDD VDD DFFNSRX2TS
Xmips_mips_c_md_accfullinstruction_reg[26] mips_mips_accfullinstruction[26]
+ 1198 clk__L1_N0 n5579 VDD VDD DFFNSRX2TS
Xmips_mips_c_md_accfullinstruction_reg[0] mips_mips_accfullinstruction[0] 1199
+ clk__L1_N0 n5605 VDD VDD DFFNSRX2TS
Xmips_mips_c_md_accfullinstruction_reg[1] mips_mips_accfullinstruction[1] 1200
+ clk__L1_N0 n5604 VDD VDD DFFNSRX2TS
Xmips_mips_c_md_accfullinstruction_reg[2] mips_mips_accfullinstruction[2] 1201
+ clk__L1_N0 n5603 VDD VDD DFFNSRX2TS
Xmips_mips_c_md_accfullinstruction_reg[3] mips_mips_accfullinstruction[3] 1202
+ clk__L1_N0 n5602 VDD VDD DFFNSRX2TS
Xmips_mips_c_md_accfullinstruction_reg[4] mips_mips_accfullinstruction[4] 1203
+ clk__L1_N0 n5601 VDD VDD DFFNSRX2TS
Xmips_mips_c_md_accfullinstruction_reg[5] mips_mips_accfullinstruction[5] 1204
+ clk__L1_N0 n5600 VDD VDD DFFNSRX2TS
Xmips_mips_c_md_accfullinstruction_reg[6] mips_mips_accfullinstruction[6] 1205
+ clk__L1_N0 n5599 VDD VDD DFFNSRX2TS
Xmips_mips_c_md_accfullinstruction_reg[7] mips_mips_accfullinstruction[7] 1206
+ clk__L1_N0 n5598 VDD VDD DFFNSRX2TS
Xmips_mips_c_md_accfullinstruction_reg[8] mips_mips_accfullinstruction[8] 1207
+ clk__L1_N0 n5597 VDD VDD DFFNSRX2TS
Xmips_mips_c_md_accfullinstruction_reg[9] mips_mips_accfullinstruction[9] 1208
+ clk__L1_N0 n5596 VDD VDD DFFNSRX2TS
Xmips_mips_c_md_accfullinstruction_reg[10] mips_mips_accfullinstruction[10]
+ 1209 clk__L1_N0 n5595 VDD VDD DFFNSRX2TS
Xmips_mips_c_md_accfullinstruction_reg[11] mips_mips_accfullinstruction[11]
+ 1210 clk__L1_N0 n5594 VDD VDD DFFNSRX2TS
Xmips_mips_c_md_accfullinstruction_reg[12] mips_mips_accfullinstruction[12]
+ 1211 clk__L1_N0 n5593 VDD VDD DFFNSRX2TS
Xmips_mips_c_md_accfullinstruction_reg[13] mips_mips_accfullinstruction[13]
+ 1212 clk__L1_N0 n5592 VDD VDD DFFNSRX2TS
Xmips_mips_c_md_accfullinstruction_reg[14] mips_mips_accfullinstruction[14]
+ 1213 clk__L1_N0 n5591 VDD VDD DFFNSRX2TS
Xmips_mips_c_md_accfullinstruction_reg[15] mips_mips_accfullinstruction[15]
+ 1214 clk__L1_N0 n5590 VDD VDD DFFNSRX2TS
Xmips_mips_c_md_accfullinstruction_reg[16] mips_mips_accfullinstruction[16]
+ 1215 clk__L1_N0 n5589 VDD VDD DFFNSRX2TS
Xmips_mips_c_md_accfullinstruction_reg[17] mips_mips_accfullinstruction[17]
+ 1216 clk__L1_N0 n5588 VDD VDD DFFNSRX2TS
Xmips_mips_c_md_accfullinstruction_reg[18] mips_mips_accfullinstruction[18]
+ 1217 clk__L1_N0 n5587 VDD VDD DFFNSRX2TS
Xmips_mips_c_md_accfullinstruction_reg[19] mips_mips_accfullinstruction[19]
+ 1218 clk__L1_N0 n5586 VDD VDD DFFNSRX2TS
Xmips_mips_c_md_accfullinstruction_reg[20] mips_mips_accfullinstruction[20]
+ 1219 clk__L1_N0 n5585 VDD VDD DFFNSRX2TS
Xmips_mips_c_md_accfullinstruction_reg[21] mips_mips_accfullinstruction[21]
+ 1220 clk__L1_N0 n5584 VDD VDD DFFNSRX2TS
Xmips_mips_c_md_accfullinstruction_reg[22] mips_mips_accfullinstruction[22]
+ 1221 clk__L1_N0 n5583 VDD VDD DFFNSRX2TS
Xmips_mips_c_md_accfullinstruction_reg[23] mips_mips_accfullinstruction[23]
+ 1222 clk__L1_N0 n5582 VDD VDD DFFNSRX2TS
Xmips_mips_c_md_accfullinstruction_reg[24] mips_mips_accfullinstruction[24]
+ 1223 clk__L1_N0 n5581 VDD VDD DFFNSRX2TS
Xmips_mips_c_md_accfullinstruction_reg[25] mips_mips_accfullinstruction[25]
+ 1224 clk__L1_N0 n5580 VDD VDD DFFNSRX2TS
Xfifo_from_fft_fifo_cell0_controller_f_i_get_reg
+ fifo_from_fft_fifo_cell0_controller_f_i_get clk__L1_N0 n5452 DFFQX1TS
Xfifo_from_fft_fifo_cell1_controller_f_i_get_reg
+ fifo_from_fft_fifo_cell1_controller_f_i_get clk__L1_N0 n6213 DFFQX1TS
Xfifo_from_fft_fifo_cell2_controller_f_i_get_reg
+ fifo_from_fft_fifo_cell2_controller_f_i_get clk__L1_N0 n6179 DFFQX1TS
Xfifo_from_fft_fifo_cell3_controller_f_i_get_reg
+ fifo_from_fft_fifo_cell3_controller_f_i_get clk__L1_N0 n6145 DFFQX1TS
Xfifo_from_fft_fifo_cell4_controller_f_i_get_reg
+ fifo_from_fft_fifo_cell4_controller_f_i_get clk__L1_N0 n6111 DFFQX1TS
Xfifo_from_fft_fifo_cell5_controller_f_i_get_reg
+ fifo_from_fft_fifo_cell5_controller_f_i_get clk__L1_N0 n6077 DFFQX1TS
Xfifo_from_fft_fifo_cell6_controller_f_i_get_reg
+ fifo_from_fft_fifo_cell6_controller_f_i_get clk__L1_N0 n6043 DFFQX1TS
Xfifo_from_fft_fifo_cell7_controller_f_i_get_reg
+ fifo_from_fft_fifo_cell7_controller_f_i_get clk__L1_N0 n6009 DFFQX1TS
Xfifo_from_fft_fifo_cell8_controller_f_i_get_reg
+ fifo_from_fft_fifo_cell8_controller_f_i_get clk__L1_N0 n5975 DFFQX1TS
Xfifo_from_fft_fifo_cell9_controller_f_i_get_reg
+ fifo_from_fft_fifo_cell9_controller_f_i_get clk__L1_N0 n5941 DFFQX1TS
Xfifo_from_fft_fifo_cell10_controller_f_i_get_reg
+ fifo_from_fft_fifo_cell10_controller_f_i_get clk__L1_N0 n5907 DFFQX1TS
Xfifo_from_fft_fifo_cell11_controller_f_i_get_reg
+ fifo_from_fft_fifo_cell11_controller_f_i_get clk__L1_N0 n5873 DFFQX1TS
Xfifo_from_fft_fifo_cell12_controller_f_i_get_reg
+ fifo_from_fft_fifo_cell12_controller_f_i_get clk__L1_N0 n5839 DFFQX1TS
Xfifo_from_fft_fifo_cell13_controller_f_i_get_reg
+ fifo_from_fft_fifo_cell13_controller_f_i_get clk__L1_N0 n5805 DFFQX1TS
Xfifo_from_fft_fifo_cell14_controller_f_i_get_reg
+ fifo_from_fft_fifo_cell14_controller_f_i_get clk__L1_N0 n5771 DFFQX1TS
Xfifo_from_fft_fifo_cell15_controller_f_i_get_reg
+ fifo_from_fft_fifo_cell15_controller_f_i_get clk__L1_N0 n5737 DFFQX1TS
Xfifo_from_fft_fifo_cell0_controller_f_i_put_reg
+ fifo_from_fft_fifo_cell0_controller_f_i_put clk__L1_N0 n6215 DFFQX1TS
Xfifo_from_fft_fifo_cell1_controller_f_i_put_reg
+ fifo_from_fft_fifo_cell1_controller_f_i_put clk__L1_N0 n6214 DFFQX1TS
Xfifo_from_fft_fifo_cell2_controller_f_i_put_reg
+ fifo_from_fft_fifo_cell2_controller_f_i_put clk__L1_N0 n6180 DFFQX1TS
Xfifo_from_fft_fifo_cell3_controller_f_i_put_reg
+ fifo_from_fft_fifo_cell3_controller_f_i_put clk__L1_N0 n6146 DFFQX1TS
Xfifo_from_fft_fifo_cell4_controller_f_i_put_reg
+ fifo_from_fft_fifo_cell4_controller_f_i_put clk__L1_N0 n6112 DFFQX1TS
Xfifo_from_fft_fifo_cell5_controller_f_i_put_reg
+ fifo_from_fft_fifo_cell5_controller_f_i_put clk__L1_N0 n6078 DFFQX1TS
Xfifo_from_fft_fifo_cell6_controller_f_i_put_reg
+ fifo_from_fft_fifo_cell6_controller_f_i_put clk__L1_N0 n6044 DFFQX1TS
Xfifo_from_fft_fifo_cell7_controller_f_i_put_reg
+ fifo_from_fft_fifo_cell7_controller_f_i_put clk__L1_N0 n6010 DFFQX1TS
Xfifo_from_fft_fifo_cell8_controller_f_i_put_reg
+ fifo_from_fft_fifo_cell8_controller_f_i_put clk__L1_N0 n5976 DFFQX1TS
Xfifo_from_fft_fifo_cell9_controller_f_i_put_reg
+ fifo_from_fft_fifo_cell9_controller_f_i_put clk__L1_N0 n5942 DFFQX1TS
Xfifo_from_fft_fifo_cell10_controller_f_i_put_reg
+ fifo_from_fft_fifo_cell10_controller_f_i_put clk__L1_N0 n5908 DFFQX1TS
Xfifo_from_fft_fifo_cell11_controller_f_i_put_reg
+ fifo_from_fft_fifo_cell11_controller_f_i_put clk__L1_N0 n5874 DFFQX1TS
Xfifo_from_fft_fifo_cell12_controller_f_i_put_reg
+ fifo_from_fft_fifo_cell12_controller_f_i_put clk__L1_N0 n5840 DFFQX1TS
Xfifo_from_fft_fifo_cell13_controller_f_i_put_reg
+ fifo_from_fft_fifo_cell13_controller_f_i_put clk__L1_N0 n5806 DFFQX1TS
Xfifo_from_fft_fifo_cell14_controller_f_i_put_reg
+ fifo_from_fft_fifo_cell14_controller_f_i_put clk__L1_N0 n5772 DFFQX1TS
Xfifo_from_fft_fifo_cell15_controller_f_i_put_reg
+ fifo_from_fft_fifo_cell15_controller_f_i_put clk__L1_N0 n5738 DFFQX1TS
Xrouter_pla_top_acc_done_reg acc_done clk__L1_N0 n5703 DFFQX1TS
Xmips_mips_c_md_accbypass_reg mips_mips_accbypass n4311 clk__L1_N0 n5702 VDD
+ VDD DFFNSRX2TS
XU3842 fifo_from_fft_fifo_cell15_data_out_N35 n4494 INVX2TS
XU3836 fifo_from_fft_fifo_cell14_data_out_N35 n4500 INVX2TS
XU3854 fifo_from_fft_fifo_cell13_data_out_N35 n4506 INVX2TS
XU3856 fifo_from_fft_fifo_cell1_data_out_N35 n4578 INVX2TS
XU3699 fifo_from_fir_fifo_cell15_data_out_N35 n4680 INVX2TS
XU3693 fifo_from_fir_fifo_cell14_data_out_N35 n4686 INVX2TS
XU3711 fifo_from_fir_fifo_cell13_data_out_N35 n4692 INVX2TS
XU3713 fifo_from_fir_fifo_cell1_data_out_N35 n4764 INVX2TS
XU1421 n4443 n4441 n4442 n4444 OAI21XLTS
XU3383 fifo_to_fir_fifo_cell2_data_out_N35 n4123 INVX2TS
XU3412 fifo_to_fir_fifo_cell4_data_out_N35 n4113 INVX2TS
XU3526 fifo_to_fft_fifo_cell2_data_out_N35 n3948 INVX2TS
XU347 n3551 n7205 FE_OFN907_n3530 FE_OFN892_n3531
+ router_addr_calc_fir_write_calc_counter_N57 AOI22XLTS
XU351 n3553 FE_OFN1266_router_addr_calc_fir_write_calc_count_9_ FE_OFN904_n3530
+ FE_OFN889_n3531 router_addr_calc_fir_write_calc_counter_N55 AOI22XLTS
XU576 n3685 FE_OFN1267_router_addr_calc_fft_read_calc_count_9_ FE_OFN885_n3662
+ FE_OFN867_n3663 router_addr_calc_fft_read_calc_counter_N55 AOI22XLTS
XU572 n3683 n7561 FE_OFN885_n3662 FE_OFN869_n3663
+ router_addr_calc_fft_read_calc_counter_N57 AOI22XLTS
XU426 n3597 router_addr_calc_fir_read_calc_count[9] FE_OFN921_n3574 n3575
+ router_addr_calc_fir_read_calc_counter_N55 AOI22XLTS
XU501 n3641 FE_OFN1268_router_addr_calc_fft_write_calc_count_9_ FE_OFN965_n3618
+ FE_OFN958_n3619 router_addr_calc_fft_write_calc_counter_N55 AOI22XLTS
XU422 n3595 n7323 FE_OFN923_n3574 FE_OFN912_n3575
+ router_addr_calc_fir_read_calc_counter_N57 AOI22XLTS
XU497 n3639 n7437 FE_OFN965_n3618 FE_OFN957_n3619
+ router_addr_calc_fft_write_calc_counter_N57 AOI22XLTS
XU475 n3628 FE_OFN1249_n7392 FE_OFN969_n3618 FE_OFN955_n3619
+ router_addr_calc_fft_write_calc_counter_N68 AOI22XLTS
XU400 n3584 FE_OFN1250_n7278 FE_OFN927_n3574 FE_OFN916_n3575
+ router_addr_calc_fir_read_calc_counter_N68 AOI22XLTS
XU325 n3540 FE_OFN1251_n7153 FE_OFN905_n3530 FE_OFN891_n3531
+ router_addr_calc_fir_write_calc_counter_N68 AOI22XLTS
XU550 n3672 n7516 FE_OFN883_n3662 FE_OFN874_n3663
+ router_addr_calc_fft_read_calc_counter_N68 AOI22XLTS
XU329 n3542 FE_OFN1257_n7165 FE_OFN905_n3530 FE_OFN895_n3531
+ router_addr_calc_fir_write_calc_counter_N66 AOI22XLTS
XU554 n3674 n7526 FE_OFN884_n3662 FE_OFN874_n3663
+ router_addr_calc_fft_read_calc_counter_N66 AOI22XLTS
XU479 n3630 FE_OFN1255_n7402 FE_OFN968_n3618 FE_OFN953_n3619
+ router_addr_calc_fft_write_calc_counter_N66 AOI22XLTS
XU404 n3586 FE_OFN1256_n7288 FE_OFN926_n3574 FE_OFN915_n3575
+ router_addr_calc_fir_read_calc_counter_N66 AOI22XLTS
XU278 n3510 n7098 FE_OFN947_n3486 FE_OFN936_n3487
+ router_addr_calc_iir_write_calc_counter_N54 AOI22XLTS
XU288 n3515 n7101 FE_OFN942_n3486 FE_OFN939_n3487
+ router_addr_calc_iir_write_calc_counter_N49 AOI22XLTS
XU272 n3507 n7109 FE_OFN948_n3486 FE_OFN935_n3487
+ router_addr_calc_iir_write_calc_counter_N57 AOI22XLTS
XU957 n5520 router_addr_calc_fir_write_calc_counter_hold n3530 FE_OFN991_n9431
+ NOR3XLTS
XU784 n5457 router_addr_calc_fft_read_calc_counter_hold FE_OFN878_n3662
+ FE_OFN974_n9462 NOR3XLTS
XU813 n5468 router_addr_calc_fft_write_calc_counter_hold n3618 FE_OFN982_n9462
+ NOR3XLTS
XU1101 n5572 router_addr_calc_fir_read_calc_counter_hold FE_OFN929_n3574 n9431
+ NOR3XLTS
XU612 n3712 FE_OFN1283_router_fft_write_done n9434 n3716 NOR3XLTS
XU609 n3709 n9406 router_fir_write_done n9389 n3710 AOI211XLTS
XU1099 n5571 router_addr_calc_fir_read_calc_counter_hold
+ router_addr_calc_fir_read_calc_counter_N40 FE_OFN985_n9431 n7211
+ FE_OFN1190_n7022 OAI32XLTS
XU811 n5467 router_addr_calc_fft_write_calc_counter_hold
+ router_addr_calc_fft_write_calc_counter_N40 FE_OFN981_n9462 n3850 n7019
+ OAI32X1TS
XU1442 n4458 router_fft_read_done INVXLTS
XU1440 n5704 router_addr_calc_fft_read_calc_counter_hold
+ router_addr_calc_fft_read_calc_counter_N40 n9462 n4458 FE_OFN1168_n7021
+ OAI32X1TS
XU955 n5519 router_addr_calc_fir_write_calc_counter_hold
+ router_addr_calc_fir_write_calc_counter_N40 FE_OFN991_n9431 n4025 n7020
+ OAI32X1TS
XU788 n3824 n3823 router_fir_put_req_reg n3825 AOI21XLTS
XU2752 n6766 router_addr_calc_iir_write_calc_counter_hold n3486 n9389 NOR3XLTS
XU1436 n3849 n7960 n3850 n4455 OAI21XLTS
XU1435 n4450 n4203 n4457 acc_done n3849 OAI211XLTS
XU3616 fifo_from_fir_fifo_cell15_N7 fifo_from_fir_fifo_cell15_reg_gtok_token
+ FE_OFN742_n4829 fifo_from_fir_fifo_cell15_data_out_N9 AND3XLTS
XU2749 n6765 router_addr_calc_iir_write_calc_counter_hold
+ router_addr_calc_iir_write_calc_counter_N40 n9389 n3717
+ router_addr_calc_iir_write_calc_counter_N212 OAI32X1TS
XU809 n5466 FE_OFN839_n7619 FE_OFN1283_router_fft_write_done n3846 n3847
+ OAI31X1TS
XU801 n5461 router_data_cntl_N151 n3839 AND2XLTS
XU793 n3833 n3476 n9434 FE_OFN1284_router_ram_read_enable_reg n3830 AOI31XLTS
XU792 n5460 FE_OFN1284_router_ram_read_enable_reg
+ router_data_cntl_fft_full_flag n3833 MX2XLTS
XU804 n5464 n3842 n7207 n3843 router_addr_calc_N95 n3844 OAI32XLTS
XU3759 fifo_from_fft_fifo_cell15_N7 fifo_from_fft_fifo_cell15_reg_gtok_token
+ FE_OFN724_n4643 fifo_from_fft_fifo_cell15_data_out_N9 AND3XLTS
XU806 n5465 n3845 n7207 router_addr_calc_N99 n3844 OAI22XLTS
XU803 n5463 FE_OFN1438_router_data_from_fft router_addr_calc_N9 FE_OFN981_n9462
+ n3841 AOI211XLTS
XU802 n5462 router_data_to_fft router_addr_calc_N63 FE_OFN980_n9462 n3840
+ AOI211XLTS
XU216 router_data_cntl_N139 n3463 n3474 n3465 to_fir_empty n3463 OAI32XLTS
XU215 router_data_cntl_N142 FE_OFN1285_router_ram_read_enable_reg n9390
+ FE_OFN977_n9462 FE_OFN990_n9431 OAI211X1TS
XU3317 mips_mips_a_N50 n4441 n4445 n4444 OAI21XLTS
XU3321 mips_mips_a_N49 n4444 INVX2TS
XU1427 n3456 n4205 INVX2TS
XU3813 n4641 n4460 INVX2TS
XU3804 n4635 n4464 INVX2TS
XU3800 n4632 n4466 INVX2TS
XU3796 n4629 n4468 INVX2TS
XU3792 n4626 n4470 INVX2TS
XU3788 n4623 n4472 INVX2TS
XU3784 n4620 n4474 INVX2TS
XU3780 n4617 n4476 INVX2TS
XU3776 n4614 n4478 INVX2TS
XU3772 n4611 n4480 INVX2TS
XU3768 n4608 n4482 INVX2TS
XU3764 n4605 n4484 INVX2TS
XU3760 n4602 n4486 INVX2TS
XU735 n3788 n3787 n8845 NOR2X1TS
XU732 n5419 n3788 FE_OFN783_n7619 n3789 n8840 n3791 OAI32X1TS
XU3670 n4827 n4646 INVX2TS
XU3661 n4821 n4650 INVX2TS
XU3657 n4818 n4652 INVX2TS
XU3653 n4815 n4654 INVX2TS
XU3649 n4812 n4656 INVX2TS
XU3645 n4809 n4658 INVX2TS
XU3641 n4806 n4660 INVX2TS
XU3637 n4803 n4662 INVX2TS
XU3633 n4800 n4664 INVX2TS
XU3629 n4797 n4666 INVX2TS
XU3625 n4794 n4668 INVX2TS
XU3621 n4791 n4670 INVX2TS
XU3617 n4788 n4672 INVX2TS
XU689 n3768 n3767 n8878 NOR2X1TS
XU686 n5384 n3768 FE_OFN804_n7619 n3769 n8873 n3771 OAI32X1TS
XU2000 n3798 n7222 n4580 n3796 OAI21X1TS
XU773 n5452 fifo_from_fft_fifo_cell0_controller_valid_read n3798 n7619
+ AOI21X1TS
XU1999 n6215 n4579 fifo_from_fft_fifo_cell0_data_out_N35 n3798 OAI21X1TS
XU2631 n3778 n7217 n4766 n3776 OAI21X1TS
XU727 n5417 fifo_from_fir_fifo_cell0_controller_valid_read n3778
+ FE_OFN809_n7619 AOI21X1TS
XU2630 n6744 n4765 fifo_from_fir_fifo_cell0_data_out_N35 n3778 OAI21X1TS
XU2024 n4597 n8840 n4599 fifo_from_fft_hang[14] n9473 OAI211X1TS
XU1477 n5737 fifo_from_fft_fifo_cell15_controller_valid_read n4491
+ FE_OFN802_n7619 AOI21X1TS
XU2655 n4783 n8873 n4785 fifo_from_fir_hang[14] n9469 OAI211X1TS
XU1514 n5771 fifo_from_fft_fifo_cell14_controller_valid_read n4497
+ FE_OFN802_n7619 AOI21X1TS
XU2108 n6266 fifo_from_fir_fifo_cell15_controller_valid_read n4677
+ FE_OFN788_n7619 AOI21X1TS
XU2145 n6300 fifo_from_fir_fifo_cell14_controller_valid_read n4683
+ FE_OFN785_n7619 AOI21X1TS
XU1551 n5805 fifo_from_fft_fifo_cell13_controller_valid_read n4503
+ FE_OFN802_n7619 AOI21X1TS
XU2182 n6334 fifo_from_fir_fifo_cell13_controller_valid_read n4689
+ FE_OFN788_n7619 AOI21X1TS
XU1588 n5839 fifo_from_fft_fifo_cell12_controller_valid_read n4509
+ FE_OFN806_n7619 AOI21X1TS
XU2219 n6368 fifo_from_fir_fifo_cell12_controller_valid_read n4695
+ FE_OFN815_n7619 AOI21X1TS
XU3368 n4167 n4036 INVX2TS
XU3356 n4158 n4042 INVX2TS
XU3344 n4149 n4048 INVX2TS
XU3340 n4146 n4050 INVX2TS
XU3398 fifo_to_fir_fifo_cell0_data_out_N35 n4133 INVX2TS
XU1075 n3807 fifo_to_fir_fifo_cell0_reg_ptok_out_valid_put
+ fifo_to_fir_fifo_cell0_reg_ptok_out_valid_get
+ fifo_to_fir_fifo_cell0_reg_ptok_N22 fifo_to_fir_fifo_cell0_reg_ptok_N29
+ OAI31X1TS
XU3517 n5244 n7321 fifo_to_fft_fifo_cell4_controller_write_enable
+ fifo_to_fft_fifo_cell4_controller_valid_read NOR3X1TS
XU3511 n3992 n3861 INVX2TS
XU3499 n3983 n3867 INVX2TS
XU3487 n3974 n3873 INVX2TS
XU3483 n3971 n3875 INVX2TS
XU3479 n3968 n3877 INVX2TS
XU3542 fifo_to_fft_fifo_cell0_data_out_N35 n3958 INVX2TS
XU931 n3818 fifo_to_fft_fifo_cell0_reg_ptok_out_valid_put
+ fifo_to_fft_fifo_cell0_reg_ptok_out_valid_get
+ fifo_to_fft_fifo_cell0_reg_ptok_N22 fifo_to_fft_fifo_cell0_reg_ptok_N29
+ OAI31X1TS
XU930 n4003 n3818 n8812 NOR2X1TS
XU928 n4005 n3814 n3815 n9496 OAI21X1TS
XU927 n5518 n4003 FE_OFN786_n7619 n4004 n8808 n4005 OAI32X1TS
XU1074 n4178 n3807 n8791 NOR2X1TS
XU1072 n4180 n3803 n3804 n9496 OAI21X1TS
XU1071 n5570 n4178 FE_OFN787_n7619 n4179 n8787 n4180 OAI32X1TS
XU1033 n5565 fifo_to_fir_fifo_cell1_controller_valid_read n4130 FE_OFN779_n7619
+ AOI21X1TS
XU889 n5513 fifo_to_fft_fifo_cell1_controller_valid_read n3955 FE_OFN794_n7619
+ AOI21X1TS
XU887 n5512 fifo_to_fft_fifo_cell1_data_out_N35 n3954 n3955 OAI21X1TS
XU1031 n5564 fifo_to_fir_fifo_cell1_data_out_N35 n4129 n4130 OAI21X1TS
XU1038 n3808 n7227 n4133 n4136 OAI21X1TS
XU894 n3819 n7232 n3958 n3961 OAI21X1TS
XU783 n5456 fifo_to_fft_fifo_cell0_controller_valid_read n3819 FE_OFN782_n7619
+ AOI21X1TS
XU1037 n5567 n4135 fifo_to_fir_fifo_cell0_data_out_N35 n3808 OAI21X1TS
XU893 n5515 n3960 fifo_to_fft_fifo_cell0_data_out_N35 n3819 OAI21X1TS
XU1041 n4137 n8789 n4055 fifo_to_fir_hang[14] n9476 OAI211X1TS
XU964 n4060 n7351 n7346 n4062 OAI21X1TS
XU963 n5523 fifo_to_fir_fifo_cell15_controller_valid_read n4060 FE_OFN798_n7619
+ AOI21X1TS
XU820 n3885 n7242 n7237 n3887 OAI21X1TS
XU819 n5471 fifo_to_fft_fifo_cell15_controller_valid_read n3885 FE_OFN792_n7619
+ AOI21X1TS
XU817 n5470 fifo_to_fft_fifo_cell15_data_out_N35 n3884 n3885 OAI21X1TS
XU961 n5522 fifo_to_fir_fifo_cell15_data_out_N35 n4059 n4060 OAI21X1TS
XU824 n5474 fifo_to_fft_fifo_cell14_controller_valid_read n3890 FE_OFN796_n7619
+ AOI21X1TS
XU968 n5526 fifo_to_fir_fifo_cell14_controller_valid_read n4065 FE_OFN805_n7619
+ AOI21X1TS
XU822 n5473 fifo_to_fft_fifo_cell14_data_out_N35 n3889 n3890 OAI21X1TS
XU966 n5525 fifo_to_fir_fifo_cell14_data_out_N35 n4064 n4065 OAI21X1TS
XU974 n4070 n7361 n4068 n7366 OAI21X1TS
XU973 n5529 fifo_to_fir_fifo_cell13_controller_valid_read n4070 FE_OFN814_n7619
+ AOI21X1TS
XU830 n3895 n7252 n3893 n7256 OAI21X1TS
XU829 n5477 fifo_to_fft_fifo_cell13_controller_valid_read n3895 FE_OFN801_n7619
+ AOI21X1TS
XU971 n5528 fifo_to_fir_fifo_cell13_data_out_N35 n4069 n4070 OAI21X1TS
XU827 n5476 fifo_to_fft_fifo_cell13_data_out_N35 n3894 n3895 OAI21X1TS
XU979 n4075 n7370 n4073 n7375 OAI21X1TS
XU978 n5532 fifo_to_fir_fifo_cell12_controller_valid_read n4075 FE_OFN810_n7619
+ AOI21X1TS
XU835 n3900 n7261 n3898 n7266 OAI21X1TS
XU834 n5480 fifo_to_fft_fifo_cell12_controller_valid_read n3900 FE_OFN813_n7619
+ AOI21X1TS
XU976 n5531 fifo_to_fir_fifo_cell12_data_out_N35 n4074 n4075 OAI21X1TS
XU832 n5479 fifo_to_fft_fifo_cell12_data_out_N35 n3899 n3900 OAI21X1TS
XU839 n5483 fifo_to_fft_fifo_cell11_controller_valid_read n3905 FE_OFN842_n7619
+ AOI21X1TS
XU983 n5535 fifo_to_fir_fifo_cell11_controller_valid_read n4080 FE_OFN816_n7619
+ AOI21X1TS
XU837 n5482 fifo_to_fft_fifo_cell11_data_out_N35 n3904 n3905 OAI21X1TS
XU981 n5534 fifo_to_fir_fifo_cell11_data_out_N35 n4079 n4080 OAI21X1TS
XU994 n4090 n7390 n4088 n7395 OAI21X1TS
XU993 n5541 fifo_to_fir_fifo_cell9_controller_valid_read n4090 FE_OFN823_n7619
+ AOI21X1TS
XU850 n3915 n7281 n3913 n7286 OAI21X1TS
XU849 n5489 fifo_to_fft_fifo_cell9_controller_valid_read n3915 FE_OFN838_n7619
+ AOI21X1TS
XU999 n4095 n7400 n4093 n7405 OAI21X1TS
XU998 n5544 fifo_to_fir_fifo_cell8_controller_valid_read n4095 FE_OFN823_n7619
+ AOI21X1TS
XU855 n3920 n7291 n3918 FE_OFN678_n7295 OAI21X1TS
XU854 n5492 fifo_to_fft_fifo_cell8_controller_valid_read n3920 FE_OFN838_n7619
+ AOI21X1TS
XU1009 n4105 n7415 n4103 n4107 OAI21X1TS
XU865 n3930 n7306 n3928 n3932 OAI21X1TS
XU870 n3935 n7311 n3933 n7316 OAI21X1TS
XU1014 n4110 n7420 n4108 n7425 OAI21X1TS
XU1013 n5553 fifo_to_fir_fifo_cell5_controller_valid_read n4110 FE_OFN811_n7619
+ AOI21X1TS
XU1024 n4120 n7435 n4118 n4122 OAI21X1TS
XU1021 n5558 fifo_to_fir_fifo_cell3_data_out_N35 n4119 n4120 OAI21X1TS
XU1067 n4174 n8791 n4176 fifo_to_fir_hang[1] n9473 OAI211X1TS
XU884 n5510 fifo_to_fft_fifo_cell2_controller_valid_read n3950 FE_OFN794_n7619
+ AOI21X1TS
XU1028 n5562 fifo_to_fir_fifo_cell2_controller_valid_read n4125 FE_OFN784_n7619
+ AOI21X1TS
XU882 n5509 fifo_to_fft_fifo_cell2_data_out_N35 n3949 n3950 OAI21X1TS
XU1026 n5561 fifo_to_fir_fifo_cell2_data_out_N35 n4124 n4125 OAI21X1TS
XU800 n3826 FE_OFN973_n7207 n7610 NOR2X1TS
XU787 n5459 n7610 n3823 n3824 OAI21X1TS
XU2737 n4841 instruction[2] n4840 NOR2X1TS
XU2733 n3848 n3455 n4840 NOR2X1TS
XU2731 n4449 router_iir_write_done n9464 n3710 n4456 n9463 AOI32X1TS
XU1434 n4452 n3710 n4456 NOR2X1TS
XU1430 n4451 router_iir_write_done n9464 n4452 n4453 n9464 AOI32X1TS
XU1429 n5703 n4204 n4449 n4450 n4451 OAI31X1TS
XU3442 fifo_to_fir_fifo_cell0_N7 fifo_to_fir_fifo_cell0_control_signal n7445
+ NOR2X1TS
XU3586 fifo_to_fft_fifo_cell0_N7 fifo_to_fft_fifo_cell0_control_signal n7336
+ NOR2X1TS
XU3855 n4506 FE_OFN722_n4643 fifo_from_fft_fifo_cell12_reg_gtok_token NAND2X1TS
XU3869 n4578 FE_OFN720_n4643 fifo_from_fft_fifo_cell0_reg_gtok_token NAND2X1TS
XU3380 n4176 n4030 INVX2TS
XU3378 n5203 n7435 fifo_to_fir_fifo_cell3_controller_write_enable
+ fifo_to_fir_fifo_cell3_controller_valid_read NOR3X1TS
XU3374 n5202 n7430 fifo_to_fir_fifo_cell4_controller_write_enable
+ fifo_to_fir_fifo_cell4_controller_valid_read NOR3X1TS
XU3372 n4170 n4034 INVX2TS
XU3364 n4164 n4038 INVX2TS
XU3360 n4161 n4040 INVX2TS
XU3352 n4155 n4044 INVX2TS
XU3348 n4152 n4046 INVX2TS
XU3338 n5193 n7361 fifo_to_fir_fifo_cell13_controller_write_enable
+ fifo_to_fir_fifo_cell13_controller_valid_read NOR3X1TS
XU3336 n4143 n4052 INVX2TS
XU3332 n4140 n4054 INVX2TS
XU3525 n5246 n7331 fifo_to_fft_fifo_cell2_controller_write_enable
+ fifo_to_fft_fifo_cell2_controller_valid_read NOR3X1TS
XU3524 n3855 n3952 fifo_to_fft_fifo_cell2_data_out_N35 n5246
+ fifo_to_fft_hold[2] AOI31X1TS
XU3515 n3995 n3859 INVX2TS
XU3507 n3989 n3863 INVX2TS
XU3503 n3986 n3865 INVX2TS
XU3495 n3980 n3869 INVX2TS
XU3491 n3977 n3871 INVX2TS
XU3475 n3965 n3879 INVX2TS
XU1920 n4562 FE_OFN835_n7619 FE_OFN314_n4561 NOR2X1TS
XU2551 n4748 FE_OFN846_n7619 FE_OFN658_n4747 NOR2X1TS
XU2588 n4754 FE_OFN833_n7619 n8137 NOR2X1TS
XU1957 n4568 FE_OFN835_n7619 n8472 NOR2X1TS
XU1994 n4574 FE_OFN840_n7619 FE_OFN337_n4573 NOR2X1TS
XU2625 n4760 FE_OFN841_n7619 FE_OFN672_n4759 NOR2X1TS
XU2722 n3834 FE_OFN1282_router_fft_get_req_reg router_fir_get_req_reg
+ FE_OFN1284_router_ram_read_enable_reg router_iir_get_req_reg NOR4XLTS
XU2703 n3828 n3754 INVX2TS
XU276 n3509 router_addr_calc_iir_write_calc_count[9] FE_OFN947_n3486
+ FE_OFN936_n3487 router_addr_calc_iir_write_calc_counter_N55 AOI22XLTS
XU608 n3706 n9432 n3708 n3709 router_fft_read_done FE_OFN977_n9462 OAI32XLTS
XU885 n3950 n7331 n3948 n3952 OAI21X1TS
XU1029 n4125 n7440 n4123 n4127 OAI21X1TS
XU2729 n4830 router_fft_get_req_reg router_ram_read_enable_reg NOR2XLTS
XU1439 n4204 router_fir_write_done n7211 n4200 AOI21XLTS
XU1103 n5573 FE_OFN843_n7619 router_fir_write_done n4200 n4201 OAI31X1TS
XU225 router_data_cntl_N134 router_data_cntl_fft_full_flag n3479 n3480 n3481
+ OAI211X1TS
XU3712 n4692 FE_OFN735_n4829 fifo_from_fir_fifo_cell12_reg_gtok_token NAND2X1TS
XU1550 n4502 FE_OFN847_n7619 n8711 NOR2X1TS
XU2181 n4688 FE_OFN828_n7619 n8376 NOR2X1TS
XU1661 n4520 FE_OFN836_n7619 FE_OFN210_n4519 NOR2X1TS
XU2715 n4644 FE_OFN776_n3829 n7606 NAND2X1TS
XU2073 n3755 n9435 FE_OFN776_n3829 NAND2X1TS
XU274 n3508 n7104 FE_OFN948_n3486 FE_OFN936_n3487
+ router_addr_calc_iir_write_calc_counter_N56 AOI22XLTS
XU270 n3506 n7115 FE_OFN948_n3486 FE_OFN935_n3487
+ router_addr_calc_iir_write_calc_counter_N58 AOI22XLTS
XU789 n3823 n3826 n7608 n3827 n3828 AOI211X1TS
XU3757 n5312 n7455 fifo_from_fft_fifo_cell15_controller_write_enable
+ fifo_from_fft_fifo_cell15_controller_valid_read NOR3X1TS
XU2714 n3832 FE_OFN990_n9431 FE_OFN776_n3829 n9389 n9433 FE_OFN776_n3829
+ AOI32X1TS
XU229 router_data_cntl_N135 n3482 FE_OFN1217_n3478 FE_OFN979_n9462 n3483
+ AOI211X1TS
XU220 router_data_cntl_N137 n3471 n3467 FE_OFN973_n7207 n3473 AOI211X1TS
XU611 n3705 n3712 n3713 n3714 n3715 AOI211X1TS
XU610 ram_read_enable n3705 n7610 NOR2X4TS
Xadd_x_22_5_U1_1_27 add_x_22_5_carry[28]
+ router_addr_calc_iir_write_calc_counter_N73
+ FE_OFN1439_router_addr_calc_iir_write_calc_count_27_ add_x_22_5_carry[27]
+ ADDHXLTS
Xadd_x_22_5_U1_1_26 add_x_22_5_carry[27]
+ router_addr_calc_iir_write_calc_counter_N72 n7181 add_x_22_5_carry[26]
+ ADDHXLTS
Xadd_x_22_5_U1_1_25 add_x_22_5_carry[26]
+ router_addr_calc_iir_write_calc_counter_N71 n7175 add_x_22_5_carry[25]
+ ADDHXLTS
Xadd_x_22_5_U1_1_24 add_x_22_5_carry[25]
+ router_addr_calc_iir_write_calc_counter_N70 n7169 add_x_22_5_carry[24]
+ ADDHXLTS
Xadd_x_22_5_U1_1_23 add_x_22_5_carry[24]
+ router_addr_calc_iir_write_calc_counter_N69
+ FE_OFN1244_router_addr_calc_iir_write_calc_count_23_ add_x_22_5_carry[23]
+ ADDHXLTS
Xadd_x_22_5_U1_1_22 add_x_22_5_carry[23]
+ router_addr_calc_iir_write_calc_counter_N68 n7163 add_x_22_5_carry[22]
+ ADDHXLTS
Xadd_x_22_5_U1_1_21 add_x_22_5_carry[22]
+ router_addr_calc_iir_write_calc_counter_N67 n7156 add_x_22_5_carry[21]
+ ADDHXLTS
Xadd_x_22_5_U1_1_20 add_x_22_5_carry[21]
+ router_addr_calc_iir_write_calc_counter_N66 n7150 add_x_22_5_carry[20]
+ ADDHXLTS
Xadd_x_22_5_U1_1_19 add_x_22_5_carry[20]
+ router_addr_calc_iir_write_calc_counter_N65
+ FE_OFN1440_router_addr_calc_iir_write_calc_count_19_ add_x_22_5_carry[19]
+ ADDHXLTS
Xadd_x_22_5_U1_1_18 add_x_22_5_carry[19]
+ router_addr_calc_iir_write_calc_counter_N64 n7144 add_x_22_5_carry[18]
+ ADDHXLTS
Xadd_x_22_5_U1_1_17 add_x_22_5_carry[18]
+ router_addr_calc_iir_write_calc_counter_N63 n7138 add_x_22_5_carry[17]
+ ADDHXLTS
Xadd_x_22_5_U1_1_16 add_x_22_5_carry[17]
+ router_addr_calc_iir_write_calc_counter_N62
+ FE_OFN1441_router_addr_calc_iir_write_calc_count_16_ add_x_22_5_carry[16]
+ ADDHXLTS
Xadd_x_22_5_U1_1_15 add_x_22_5_carry[16]
+ router_addr_calc_iir_write_calc_counter_N61 n7132 add_x_22_5_carry[15]
+ ADDHXLTS
Xadd_x_22_5_U1_1_14 add_x_22_5_carry[15]
+ router_addr_calc_iir_write_calc_counter_N60 n7126 add_x_22_5_carry[14]
+ ADDHXLTS
Xadd_x_22_5_U1_1_13 add_x_22_5_carry[14]
+ router_addr_calc_iir_write_calc_counter_N59 n7121 add_x_22_5_carry[13]
+ ADDHXLTS
Xadd_x_22_5_U1_1_12 add_x_22_5_carry[13]
+ router_addr_calc_iir_write_calc_counter_N58 n7115 add_x_22_5_carry[12]
+ ADDHXLTS
Xadd_x_22_5_U1_1_11 add_x_22_5_carry[12]
+ router_addr_calc_iir_write_calc_counter_N57 n7109 add_x_22_5_carry[11]
+ ADDHXLTS
Xadd_x_22_5_U1_1_10 add_x_22_5_carry[11]
+ router_addr_calc_iir_write_calc_counter_N56 n7104 add_x_22_5_carry[10]
+ ADDHXLTS
Xadd_x_22_5_U1_1_9 add_x_22_5_carry[10]
+ router_addr_calc_iir_write_calc_counter_N55
+ FE_OFN1280_router_addr_calc_iir_write_calc_count_9_ add_x_22_5_carry[9]
+ ADDHXLTS
Xadd_x_22_5_U1_1_8 add_x_22_5_carry[9]
+ router_addr_calc_iir_write_calc_counter_N54 n7098 add_x_22_5_carry[8]
+ ADDHXLTS
Xadd_x_22_5_U1_1_7 add_x_22_5_carry[8]
+ router_addr_calc_iir_write_calc_counter_N53 n7092 add_x_22_5_carry[7]
+ ADDHXLTS
Xadd_x_22_5_U1_1_6 add_x_22_5_carry[7]
+ router_addr_calc_iir_write_calc_counter_N52 n7089 add_x_22_5_carry[6]
+ ADDHXLTS
Xadd_x_22_5_U1_1_5 add_x_22_5_carry[6]
+ router_addr_calc_iir_write_calc_counter_N51
+ FE_OFN1281_router_addr_calc_iir_write_calc_count_5_ add_x_22_5_carry[5]
+ ADDHXLTS
Xadd_x_22_5_U1_1_4 add_x_22_5_carry[5]
+ router_addr_calc_iir_write_calc_counter_N50 n7095 add_x_22_5_carry[4]
+ ADDHXLTS
Xadd_x_22_5_U1_1_3 add_x_22_5_carry[4]
+ router_addr_calc_iir_write_calc_counter_N49 n7101 add_x_22_5_carry[3]
+ ADDHXLTS
Xadd_x_22_5_U1_1_2 add_x_22_5_carry[3]
+ router_addr_calc_iir_write_calc_counter_N48 FE_OFN1825_n7107
+ add_x_22_5_carry[2] ADDHXLTS
Xadd_x_22_5_U1_1_1 add_x_22_5_carry[2]
+ router_addr_calc_iir_write_calc_counter_N47 n7112
+ FE_OFN1442_router_addr_calc_iir_write_calc_count_0_ ADDHXLTS
Xadd_x_22_3_U1_1_27 add_x_22_3_carry[28]
+ router_addr_calc_fir_write_calc_counter_N73
+ router_addr_calc_fir_write_calc_count[27] add_x_22_3_carry[27] ADDHXLTS
Xadd_x_22_3_U1_1_26 add_x_22_3_carry[27]
+ router_addr_calc_fir_write_calc_counter_N72 n7136 add_x_22_3_carry[26]
+ ADDHXLTS
Xadd_x_22_3_U1_1_25 add_x_22_3_carry[26]
+ router_addr_calc_fir_write_calc_counter_N71 n7142 add_x_22_3_carry[25]
+ ADDHXLTS
Xadd_x_22_3_U1_1_24 add_x_22_3_carry[25]
+ router_addr_calc_fir_write_calc_counter_N70 n7148 add_x_22_3_carry[24]
+ ADDHXLTS
Xadd_x_22_3_U1_1_23 add_x_22_3_carry[24]
+ router_addr_calc_fir_write_calc_counter_N69
+ FE_OFN1248_router_addr_calc_fir_write_calc_count_23_ add_x_22_3_carry[23]
+ ADDHXLTS
Xadd_x_22_3_U1_1_22 add_x_22_3_carry[23]
+ router_addr_calc_fir_write_calc_counter_N68 n7154 add_x_22_3_carry[22]
+ ADDHXLTS
Xadd_x_22_3_U1_1_21 add_x_22_3_carry[22]
+ router_addr_calc_fir_write_calc_counter_N67 n7160 add_x_22_3_carry[21]
+ ADDHXLTS
Xadd_x_22_3_U1_1_20 add_x_22_3_carry[21]
+ router_addr_calc_fir_write_calc_counter_N66 FE_OFN1257_n7165
+ add_x_22_3_carry[20] ADDHXLTS
Xadd_x_22_3_U1_1_19 add_x_22_3_carry[20]
+ router_addr_calc_fir_write_calc_counter_N65
+ router_addr_calc_fir_write_calc_count[19] add_x_22_3_carry[19] ADDHXLTS
Xadd_x_22_3_U1_1_18 add_x_22_3_carry[19]
+ router_addr_calc_fir_write_calc_counter_N64 n7171 add_x_22_3_carry[18]
+ ADDHXLTS
Xadd_x_22_3_U1_1_17 add_x_22_3_carry[18]
+ router_addr_calc_fir_write_calc_counter_N63 n7177 add_x_22_3_carry[17]
+ ADDHXLTS
Xadd_x_22_3_U1_1_16 add_x_22_3_carry[17]
+ router_addr_calc_fir_write_calc_counter_N62
+ router_addr_calc_fir_write_calc_count[16] add_x_22_3_carry[16] ADDHXLTS
Xadd_x_22_3_U1_1_15 add_x_22_3_carry[16]
+ router_addr_calc_fir_write_calc_counter_N61 n7183 add_x_22_3_carry[15]
+ ADDHXLTS
Xadd_x_22_3_U1_1_14 add_x_22_3_carry[15]
+ router_addr_calc_fir_write_calc_counter_N60 n7189 add_x_22_3_carry[14]
+ ADDHXLTS
Xadd_x_22_3_U1_1_13 add_x_22_3_carry[14]
+ router_addr_calc_fir_write_calc_counter_N59 n7195 add_x_22_3_carry[13]
+ ADDHXLTS
Xadd_x_22_3_U1_1_12 add_x_22_3_carry[13]
+ router_addr_calc_fir_write_calc_counter_N58 n7201 add_x_22_3_carry[12]
+ ADDHXLTS
Xadd_x_22_3_U1_1_11 add_x_22_3_carry[12]
+ router_addr_calc_fir_write_calc_counter_N57 n7205 add_x_22_3_carry[11]
+ ADDHXLTS
Xadd_x_22_3_U1_1_10 add_x_22_3_carry[11]
+ router_addr_calc_fir_write_calc_counter_N56 n7209 add_x_22_3_carry[10]
+ ADDHXLTS
Xadd_x_22_3_U1_1_9 add_x_22_3_carry[10]
+ router_addr_calc_fir_write_calc_counter_N55
+ FE_OFN1266_router_addr_calc_fir_write_calc_count_9_ add_x_22_3_carry[9]
+ ADDHXLTS
Xadd_x_22_3_U1_1_8 add_x_22_3_carry[9]
+ router_addr_calc_fir_write_calc_counter_N54 n7214 add_x_22_3_carry[8]
+ ADDHXLTS
Xadd_x_22_3_U1_1_7 add_x_22_3_carry[8]
+ router_addr_calc_fir_write_calc_counter_N53 n7219 add_x_22_3_carry[7]
+ ADDHXLTS
Xadd_x_22_3_U1_1_6 add_x_22_3_carry[7]
+ router_addr_calc_fir_write_calc_counter_N52 n7224 add_x_22_3_carry[6]
+ ADDHXLTS
Xadd_x_22_3_U1_1_5 add_x_22_3_carry[6]
+ router_addr_calc_fir_write_calc_counter_N51
+ FE_OFN1272_router_addr_calc_fir_write_calc_count_5_ add_x_22_3_carry[5]
+ ADDHXLTS
Xadd_x_22_3_U1_1_4 add_x_22_3_carry[5]
+ router_addr_calc_fir_write_calc_counter_N50 n7229 add_x_22_3_carry[4]
+ ADDHXLTS
Xadd_x_22_3_U1_1_3 add_x_22_3_carry[4]
+ router_addr_calc_fir_write_calc_counter_N49 n7234 add_x_22_3_carry[3]
+ ADDHXLTS
Xadd_x_22_3_U1_1_2 add_x_22_3_carry[3]
+ router_addr_calc_fir_write_calc_counter_N48 n7239 add_x_22_3_carry[2]
+ ADDHXLTS
Xadd_x_22_2_U1_1_27 add_x_22_2_carry[28]
+ router_addr_calc_fir_read_calc_counter_N73
+ FE_OFN1239_router_addr_calc_fir_read_calc_count_27_ add_x_22_2_carry[27]
+ ADDHXLTS
Xadd_x_22_2_U1_1_26 add_x_22_2_carry[27]
+ router_addr_calc_fir_read_calc_counter_N72 FE_OFN1241_n7264
+ add_x_22_2_carry[26] ADDHXLTS
Xadd_x_22_2_U1_1_25 add_x_22_2_carry[26]
+ router_addr_calc_fir_read_calc_counter_N71 n7269 add_x_22_2_carry[25]
+ ADDHXLTS
Xadd_x_22_2_U1_1_24 add_x_22_2_carry[25]
+ router_addr_calc_fir_read_calc_counter_N70 n7274 add_x_22_2_carry[24]
+ ADDHXLTS
Xadd_x_22_2_U1_1_23 add_x_22_2_carry[24]
+ router_addr_calc_fir_read_calc_counter_N69
+ FE_OFN1247_router_addr_calc_fir_read_calc_count_23_ add_x_22_2_carry[23]
+ ADDHXLTS
Xadd_x_22_2_U1_1_22 add_x_22_2_carry[23]
+ router_addr_calc_fir_read_calc_counter_N68 n7279 add_x_22_2_carry[22]
+ ADDHXLTS
Xadd_x_22_2_U1_1_21 add_x_22_2_carry[22]
+ router_addr_calc_fir_read_calc_counter_N67 n7284 add_x_22_2_carry[21]
+ ADDHXLTS
Xadd_x_22_2_U1_1_20 add_x_22_2_carry[21]
+ router_addr_calc_fir_read_calc_counter_N66 FE_OFN1256_n7288
+ add_x_22_2_carry[20] ADDHXLTS
Xadd_x_22_2_U1_1_19 add_x_22_2_carry[20]
+ router_addr_calc_fir_read_calc_counter_N65
+ router_addr_calc_fir_read_calc_count[19] add_x_22_2_carry[19] ADDHXLTS
Xadd_x_22_2_U1_1_18 add_x_22_2_carry[19]
+ router_addr_calc_fir_read_calc_counter_N64 n7293 add_x_22_2_carry[18]
+ ADDHXLTS
Xadd_x_22_2_U1_1_17 add_x_22_2_carry[18]
+ router_addr_calc_fir_read_calc_counter_N63 FE_OFN1262_n7298
+ add_x_22_2_carry[17] ADDHXLTS
Xadd_x_22_2_U1_1_16 add_x_22_2_carry[17]
+ router_addr_calc_fir_read_calc_counter_N62 FE_OFN1265_n7303
+ add_x_22_2_carry[16] ADDHXLTS
Xadd_x_22_2_U1_1_15 add_x_22_2_carry[16]
+ router_addr_calc_fir_read_calc_counter_N61
+ FE_OFN1271_router_addr_calc_fir_read_calc_count_15_ add_x_22_2_carry[15]
+ ADDHXLTS
Xadd_x_22_2_U1_1_14 add_x_22_2_carry[15]
+ router_addr_calc_fir_read_calc_counter_N60 FE_OFN1277_n7308
+ add_x_22_2_carry[14] ADDHXLTS
Xadd_x_22_2_U1_1_13 add_x_22_2_carry[14]
+ router_addr_calc_fir_read_calc_counter_N59 n7313 add_x_22_2_carry[13]
+ ADDHXLTS
Xadd_x_22_2_U1_1_12 add_x_22_2_carry[13]
+ router_addr_calc_fir_read_calc_counter_N58 n7318 add_x_22_2_carry[12]
+ ADDHXLTS
Xadd_x_22_2_U1_1_11 add_x_22_2_carry[12]
+ router_addr_calc_fir_read_calc_counter_N57 n7323 add_x_22_2_carry[11]
+ ADDHXLTS
Xadd_x_22_2_U1_1_10 add_x_22_2_carry[11]
+ router_addr_calc_fir_read_calc_counter_N56 FE_OFN1279_n7328
+ add_x_22_2_carry[10] ADDHXLTS
Xadd_x_22_2_U1_1_9 add_x_22_2_carry[10]
+ router_addr_calc_fir_read_calc_counter_N55
+ FE_OFN1269_router_addr_calc_fir_read_calc_count_9_ add_x_22_2_carry[9]
+ ADDHXLTS
Xadd_x_22_2_U1_1_8 add_x_22_2_carry[9]
+ router_addr_calc_fir_read_calc_counter_N54 FE_OFN1278_n7333
+ add_x_22_2_carry[8] ADDHXLTS
Xadd_x_22_2_U1_1_7 add_x_22_2_carry[8]
+ router_addr_calc_fir_read_calc_counter_N53 n7338 add_x_22_2_carry[7] ADDHXLTS
Xadd_x_22_2_U1_1_6 add_x_22_2_carry[7]
+ router_addr_calc_fir_read_calc_counter_N52 n7343 add_x_22_2_carry[6] ADDHXLTS
Xadd_x_22_2_U1_1_5 add_x_22_2_carry[6]
+ router_addr_calc_fir_read_calc_counter_N51
+ FE_OFN1824_router_addr_calc_fir_read_calc_count_5_ add_x_22_2_carry[5]
+ ADDHXLTS
Xadd_x_22_2_U1_1_4 add_x_22_2_carry[5]
+ router_addr_calc_fir_read_calc_counter_N50 n7348 add_x_22_2_carry[4] ADDHXLTS
Xadd_x_22_2_U1_1_3 add_x_22_2_carry[4]
+ router_addr_calc_fir_read_calc_counter_N49 FE_OFN1275_n7353
+ add_x_22_2_carry[3] ADDHXLTS
Xadd_x_22_2_U1_1_2 add_x_22_2_carry[3]
+ router_addr_calc_fir_read_calc_counter_N48 FE_OFN1274_n7358
+ add_x_22_2_carry[2] ADDHXLTS
Xadd_x_22_1_U1_1_29 add_x_22_1_carry[30]
+ router_addr_calc_fft_write_calc_counter_N75
+ FE_OFN1233_router_addr_calc_fft_write_calc_count_29_ add_x_22_1_carry[29]
+ ADDHXLTS
Xadd_x_22_1_U1_1_27 add_x_22_1_carry[28]
+ router_addr_calc_fft_write_calc_counter_N73
+ FE_OFN1238_router_addr_calc_fft_write_calc_count_27_ add_x_22_1_carry[27]
+ ADDHXLTS
Xadd_x_22_1_U1_1_26 add_x_22_1_carry[27]
+ router_addr_calc_fft_write_calc_counter_N72 n7378 add_x_22_1_carry[26]
+ ADDHXLTS
Xadd_x_22_1_U1_1_25 add_x_22_1_carry[26]
+ router_addr_calc_fft_write_calc_counter_N71 n7383 add_x_22_1_carry[25]
+ ADDHXLTS
Xadd_x_22_1_U1_1_24 add_x_22_1_carry[25]
+ router_addr_calc_fft_write_calc_counter_N70 n7388 add_x_22_1_carry[24]
+ ADDHXLTS
Xadd_x_22_1_U1_1_23 add_x_22_1_carry[24]
+ router_addr_calc_fft_write_calc_counter_N69
+ FE_OFN1246_router_addr_calc_fft_write_calc_count_23_ add_x_22_1_carry[23]
+ ADDHXLTS
Xadd_x_22_1_U1_1_22 add_x_22_1_carry[23]
+ router_addr_calc_fft_write_calc_counter_N68 n7393 add_x_22_1_carry[22]
+ ADDHXLTS
Xadd_x_22_1_U1_1_21 add_x_22_1_carry[22]
+ router_addr_calc_fft_write_calc_counter_N67 n7398 add_x_22_1_carry[21]
+ ADDHXLTS
Xadd_x_22_1_U1_1_20 add_x_22_1_carry[21]
+ router_addr_calc_fft_write_calc_counter_N66 FE_OFN1255_n7402
+ add_x_22_1_carry[20] ADDHXLTS
Xadd_x_22_1_U1_1_19 add_x_22_1_carry[20]
+ router_addr_calc_fft_write_calc_counter_N65
+ FE_OFN1259_router_addr_calc_fft_write_calc_count_19_ add_x_22_1_carry[19]
+ ADDHXLTS
Xadd_x_22_1_U1_1_18 add_x_22_1_carry[19]
+ router_addr_calc_fft_write_calc_counter_N64 n7407 add_x_22_1_carry[18]
+ ADDHXLTS
Xadd_x_22_1_U1_1_17 add_x_22_1_carry[18]
+ router_addr_calc_fft_write_calc_counter_N63 n7412 add_x_22_1_carry[17]
+ ADDHXLTS
Xadd_x_22_1_U1_1_16 add_x_22_1_carry[17]
+ router_addr_calc_fft_write_calc_counter_N62 n7417 add_x_22_1_carry[16]
+ ADDHXLTS
Xadd_x_22_1_U1_1_15 add_x_22_1_carry[16]
+ router_addr_calc_fft_write_calc_counter_N61
+ FE_OFN1270_router_addr_calc_fft_write_calc_count_15_ add_x_22_1_carry[15]
+ ADDHXLTS
Xadd_x_22_1_U1_1_14 add_x_22_1_carry[15]
+ router_addr_calc_fft_write_calc_counter_N60 n7422 add_x_22_1_carry[14]
+ ADDHXLTS
Xadd_x_22_1_U1_1_13 add_x_22_1_carry[14]
+ router_addr_calc_fft_write_calc_counter_N59 n7427 add_x_22_1_carry[13]
+ ADDHXLTS
Xadd_x_22_1_U1_1_12 add_x_22_1_carry[13]
+ router_addr_calc_fft_write_calc_counter_N58 n7432 add_x_22_1_carry[12]
+ ADDHXLTS
Xadd_x_22_1_U1_1_11 add_x_22_1_carry[12]
+ router_addr_calc_fft_write_calc_counter_N57 n7437 add_x_22_1_carry[11]
+ ADDHXLTS
Xadd_x_22_1_U1_1_10 add_x_22_1_carry[11]
+ router_addr_calc_fft_write_calc_counter_N56 n7442 add_x_22_1_carry[10]
+ ADDHXLTS
Xadd_x_22_1_U1_1_9 add_x_22_1_carry[10]
+ router_addr_calc_fft_write_calc_counter_N55
+ FE_OFN1268_router_addr_calc_fft_write_calc_count_9_ add_x_22_1_carry[9]
+ ADDHXLTS
Xadd_x_22_1_U1_1_8 add_x_22_1_carry[9]
+ router_addr_calc_fft_write_calc_counter_N54 n7447 add_x_22_1_carry[8]
+ ADDHXLTS
Xadd_x_22_1_U1_1_7 add_x_22_1_carry[8]
+ router_addr_calc_fft_write_calc_counter_N53 n7452 add_x_22_1_carry[7]
+ ADDHXLTS
Xadd_x_22_1_U1_1_6 add_x_22_1_carry[7]
+ router_addr_calc_fft_write_calc_counter_N52 n7457 add_x_22_1_carry[6]
+ ADDHXLTS
Xadd_x_22_1_U1_1_5 add_x_22_1_carry[6]
+ router_addr_calc_fft_write_calc_counter_N51 n7462 add_x_22_1_carry[5]
+ ADDHXLTS
Xadd_x_22_1_U1_1_4 add_x_22_1_carry[5]
+ router_addr_calc_fft_write_calc_counter_N50 n7467 add_x_22_1_carry[4]
+ ADDHXLTS
Xadd_x_22_1_U1_1_3 add_x_22_1_carry[4]
+ router_addr_calc_fft_write_calc_counter_N49 n7472 add_x_22_1_carry[3]
+ ADDHXLTS
Xadd_x_22_1_U1_1_2 add_x_22_1_carry[3]
+ router_addr_calc_fft_write_calc_counter_N48 n7477 add_x_22_1_carry[2]
+ ADDHXLTS
Xadd_x_22_0_U1_1_27 add_x_22_0_carry[28]
+ router_addr_calc_fft_read_calc_counter_N73
+ router_addr_calc_fft_read_calc_count[27] add_x_22_0_carry[27] ADDHXLTS
Xadd_x_22_0_U1_1_26 add_x_22_0_carry[27]
+ router_addr_calc_fft_read_calc_counter_N72 n7502 add_x_22_0_carry[26]
+ ADDHXLTS
Xadd_x_22_0_U1_1_25 add_x_22_0_carry[26]
+ router_addr_calc_fft_read_calc_counter_N71 n7507 add_x_22_0_carry[25]
+ ADDHXLTS
Xadd_x_22_0_U1_1_24 add_x_22_0_carry[25]
+ router_addr_calc_fft_read_calc_counter_N70 n7512 add_x_22_0_carry[24]
+ ADDHXLTS
Xadd_x_22_0_U1_1_23 add_x_22_0_carry[24]
+ router_addr_calc_fft_read_calc_counter_N69
+ router_addr_calc_fft_read_calc_count[23] add_x_22_0_carry[23] ADDHXLTS
Xadd_x_22_0_U1_1_22 add_x_22_0_carry[23]
+ router_addr_calc_fft_read_calc_counter_N68 n7517 add_x_22_0_carry[22]
+ ADDHXLTS
Xadd_x_22_0_U1_1_21 add_x_22_0_carry[22]
+ router_addr_calc_fft_read_calc_counter_N67 n7522 add_x_22_0_carry[21]
+ ADDHXLTS
Xadd_x_22_0_U1_1_20 add_x_22_0_carry[21]
+ router_addr_calc_fft_read_calc_counter_N66 n7526 add_x_22_0_carry[20]
+ ADDHXLTS
Xadd_x_22_0_U1_1_19 add_x_22_0_carry[20]
+ router_addr_calc_fft_read_calc_counter_N65
+ router_addr_calc_fft_read_calc_count[19] add_x_22_0_carry[19] ADDHXLTS
Xadd_x_22_0_U1_1_18 add_x_22_0_carry[19]
+ router_addr_calc_fft_read_calc_counter_N64 n7531 add_x_22_0_carry[18]
+ ADDHXLTS
Xadd_x_22_0_U1_1_17 add_x_22_0_carry[18]
+ router_addr_calc_fft_read_calc_counter_N63 n7536 add_x_22_0_carry[17]
+ ADDHXLTS
Xadd_x_22_0_U1_1_16 add_x_22_0_carry[17]
+ router_addr_calc_fft_read_calc_counter_N62
+ FE_OFN1263_router_addr_calc_fft_read_calc_count_16_ add_x_22_0_carry[16]
+ ADDHXLTS
Xadd_x_22_0_U1_1_15 add_x_22_0_carry[16]
+ router_addr_calc_fft_read_calc_counter_N61 n7541 add_x_22_0_carry[15]
+ ADDHXLTS
Xadd_x_22_0_U1_1_14 add_x_22_0_carry[15]
+ router_addr_calc_fft_read_calc_counter_N60 n7546 add_x_22_0_carry[14]
+ ADDHXLTS
Xadd_x_22_0_U1_1_13 add_x_22_0_carry[14]
+ router_addr_calc_fft_read_calc_counter_N59 n7551 add_x_22_0_carry[13]
+ ADDHXLTS
Xadd_x_22_0_U1_1_12 add_x_22_0_carry[13]
+ router_addr_calc_fft_read_calc_counter_N58 n7556 add_x_22_0_carry[12]
+ ADDHXLTS
Xadd_x_22_0_U1_1_11 add_x_22_0_carry[12]
+ router_addr_calc_fft_read_calc_counter_N57 n7561 add_x_22_0_carry[11]
+ ADDHXLTS
Xadd_x_22_0_U1_1_10 add_x_22_0_carry[11]
+ router_addr_calc_fft_read_calc_counter_N56 n7566 add_x_22_0_carry[10]
+ ADDHXLTS
Xadd_x_22_0_U1_1_9 add_x_22_0_carry[10]
+ router_addr_calc_fft_read_calc_counter_N55
+ FE_OFN1267_router_addr_calc_fft_read_calc_count_9_ add_x_22_0_carry[9]
+ ADDHXLTS
Xadd_x_22_0_U1_1_8 add_x_22_0_carry[9]
+ router_addr_calc_fft_read_calc_counter_N54 n7571 add_x_22_0_carry[8] ADDHXLTS
Xadd_x_22_0_U1_1_7 add_x_22_0_carry[8]
+ router_addr_calc_fft_read_calc_counter_N53 n7576 add_x_22_0_carry[7] ADDHXLTS
Xadd_x_22_0_U1_1_6 add_x_22_0_carry[7]
+ router_addr_calc_fft_read_calc_counter_N52 n7581 add_x_22_0_carry[6] ADDHXLTS
Xadd_x_22_0_U1_1_5 add_x_22_0_carry[6]
+ router_addr_calc_fft_read_calc_counter_N51
+ FE_OFN1273_router_addr_calc_fft_read_calc_count_5_ add_x_22_0_carry[5]
+ ADDHXLTS
Xadd_x_22_0_U1_1_4 add_x_22_0_carry[5]
+ router_addr_calc_fft_read_calc_counter_N50 n7586 add_x_22_0_carry[4] ADDHXLTS
Xadd_x_22_0_U1_1_3 add_x_22_0_carry[4]
+ router_addr_calc_fft_read_calc_counter_N49 n7591 add_x_22_0_carry[3] ADDHXLTS
Xadd_x_22_0_U1_1_2 add_x_22_0_carry[3]
+ router_addr_calc_fft_read_calc_counter_N48 n7596 add_x_22_0_carry[2] ADDHXLTS
XU3590 n3482 to_fft_empty INVX2TS
XU3446 n3471 to_fir_empty INVX2TS
XU2649 n3769 fifo_from_fir_tok_xnor_put CLKINVX2TS
XU607 n3707 router_ram_write_enable_reg INVX2TS
XU951 n4004 fifo_to_fft_tok_xnor_put INVX1TS
XU3473 n4009 fifo_to_fft_hang[14] CLKINVX1TS
XU2751 n3717 router_iir_write_done INVX1TS
XU1433 n4025 router_fir_write_done INVX2TS
XU1095 n4179 fifo_to_fir_tok_xnor_put INVX1TS
XU3330 n4184 fifo_to_fir_hang[14] CLKINVX1TS
XU2018 n3789 fifo_from_fft_tok_xnor_put CLKINVX2TS
XU2750 router_addr_calc_iir_write_calc_counter_N212
+ router_addr_calc_iir_write_calc_counter_hold INVX2TS
XU3318 n4445 mips_mips_a_count[0] CLKINVX2TS
XU602 n3704 n7487 n7592 n7586
+ FE_OFN1273_router_addr_calc_fft_read_calc_count_5_ NAND4XLTS
XU3872 n3850 FE_OFN1283_router_fft_write_done INVX2TS
XU600 n3697 n7552 n7547 n7542
+ FE_OFN1263_router_addr_calc_fft_read_calc_count_16_ NAND4XLTS
XU603 n3703 n7582 n7577 n7572
+ FE_OFN1267_router_addr_calc_fft_read_calc_count_9_ NAND4XLTS
XU373 n3567 n7166 n7160 n7154
+ FE_OFN1248_router_addr_calc_fir_write_calc_count_23_ NAND4XLTS
XU374 n3566 FE_OFN1445_router_addr_calc_fir_write_calc_count_0_ n7210 n7206
+ n7202 NAND4XLTS
XU375 n3565 n7196 n7190 n7184
+ FE_OFN1264_router_addr_calc_fir_write_calc_count_16_ NAND4XLTS
XU377 n3572 n7118 n7235 n7229
+ FE_OFN1272_router_addr_calc_fir_write_calc_count_5_ NAND4XLTS
XU378 n3571 n7225 n7220 n7215 router_addr_calc_fir_write_calc_count[9]
+ NAND4XLTS
XU379 n3570 n7148 n7142 n7135
+ FE_OFN1240_router_addr_calc_fir_write_calc_count_27_ NAND4XLTS
XU380 n3569 n7129 n7124 n7240
+ FE_OFN1231_router_addr_calc_fir_write_calc_count_30_ NAND4XLTS
XU604 n3702 n7512 n7507 n7501
+ FE_OFN1237_router_addr_calc_fft_read_calc_count_27_ NAND4XLTS
XU605 n3701 n7496 FE_OFN1234_n7492 n7597
+ FE_OFN1229_router_addr_calc_fft_read_calc_count_30_ NAND4XLTS
XU372 n3568 n7178 n7171 FE_OFN1261_router_addr_calc_fir_write_calc_count_19_
+ n7244 NAND4XLTS
XU529 n3658 n7388 n7383 n7377
+ FE_OFN1238_router_addr_calc_fft_write_calc_count_27_ NAND4XLTS
XU597 n3700 n7537 n7531 FE_OFN1258_router_addr_calc_fft_read_calc_count_19_
+ n7601 NAND4XLTS
XU302 n3528 n7198 n7102 n7095
+ FE_OFN1281_router_addr_calc_iir_write_calc_count_5_ NAND4XLTS
XU303 n3527 n7090 n7093 n7099
+ FE_OFN1280_router_addr_calc_iir_write_calc_count_9_ NAND4XLTS
XU523 n3655 n7403 n7398 n7393
+ FE_OFN1246_router_addr_calc_fft_write_calc_count_23_ NAND4XLTS
XU525 n3653 n7428 n7423 FE_OFN1270_router_addr_calc_fft_write_calc_count_15_
+ n7418 NAND4XLTS
XU304 n3526 n7169 n7175 n7180
+ FE_OFN1439_router_addr_calc_iir_write_calc_count_27_ NAND4XLTS
XU305 n3525 n7186 n7192 FE_OFN1825_n7107
+ router_addr_calc_iir_write_calc_count[30] NAND4XLTS
XU449 n3610 router_addr_calc_fir_read_calc_count[0] n7329 n7324 n7319 NAND4XLTS
XU448 n3611 n7289 n7284 n7279
+ FE_OFN1247_router_addr_calc_fir_read_calc_count_23_ NAND4XLTS
XU450 n3609 n7314 n7309 FE_OFN1271_router_addr_calc_fir_read_calc_count_15_
+ n7304 NAND4XLTS
XU452 n3616 n7249 n7354 n7348
+ FE_OFN1276_router_addr_calc_fir_read_calc_count_5_ NAND4XLTS
XU297 n3524 n7139 n7144 FE_OFN1440_router_addr_calc_iir_write_calc_count_19_
+ n7112 NAND4XLTS
XU447 n3612 n7299 n7293 FE_OFN1260_router_addr_calc_fir_read_calc_count_19_
+ n7363 NAND4XLTS
XU453 n3615 n7344 n7339 n7334
+ FE_OFN1269_router_addr_calc_fir_read_calc_count_9_ NAND4XLTS
XU530 n3657 n7372 FE_OFN1233_router_addr_calc_fft_write_calc_count_29_ n7478
+ FE_OFN1232_n7368 NAND4XLTS
XU298 n3523 n7151 n7157 n7163 router_addr_calc_iir_write_calc_count[23]
+ NAND4XLTS
XU454 n3614 n7274 n7269 n7263 router_addr_calc_fir_read_calc_count[27]
+ NAND4XLTS
XU299 n3522 FE_OFN1442_router_addr_calc_iir_write_calc_count_0_ n7105 n7110
+ n7116 NAND4XLTS
XU455 n3613 n7258 FE_OFN1235_n7254 n7359
+ FE_OFN1230_router_addr_calc_fir_read_calc_count_30_ NAND4XLTS
XU522 n3656 n7413 n7407 FE_OFN1259_router_addr_calc_fft_write_calc_count_19_
+ n7482 NAND4XLTS
XU300 n3521 n7122 n7127 n7133
+ FE_OFN1441_router_addr_calc_iir_write_calc_count_16_ NAND4XLTS
XU599 n3698 FE_OFN1444_router_addr_calc_fft_read_calc_count_0_ n7567 n7562
+ n7557 NAND4XLTS
XU527 n3660 FE_OFN1228_router_addr_calc_fft_write_calc_count_31_ n7473 n7467
+ n7462 NAND4XLTS
XU524 n3654 FE_OFN1443_router_addr_calc_fft_write_calc_count_0_ n7443 n7438
+ n7433 NAND4XLTS
XU528 n3659 n7458 n7453 n7448 router_addr_calc_fft_write_calc_count[9]
+ NAND4XLTS
XU598 n3699 n7527 n7522 n7517
+ FE_OFN1245_router_addr_calc_fft_read_calc_count_23_ NAND4XLTS
XU2728 n4832 n4830 router_iir_get_req_reg n7603 NAND3XLTS
XU3538 n3714 router_fft_write_done router_fft_read_done FE_OFN974_n9462
+ NOR3X1TS
XU614 n3708 FE_OFN988_n9431 n7212 NOR2XLTS
XU2713 n3472 FE_OFN978_n9462 n9407 AND2XLTS
XU613 n3716 n3708 FE_OFN1286_iir_enable n3710 n3717 NAND4BXLTS
XU3871 n5346 router_fft_read_done n3850 n9433 router_fft_get_req_reg OAI211X2TS
XU828 n3894 fifo_to_fft_fifo_cell13_controller_f_i_put n9498 NAND2XLTS
XU818 n3884 fifo_to_fft_fifo_cell15_controller_f_i_put n9498 NAND2XLTS
XU833 n3899 fifo_to_fft_fifo_cell12_controller_f_i_put n9498 NAND2XLTS
XU838 n3904 fifo_to_fft_fifo_cell11_controller_f_i_put n9499 NAND2XLTS
XU843 n3909 fifo_to_fft_fifo_cell10_controller_f_i_put n9497 NAND2XLTS
XU848 n3914 fifo_to_fft_fifo_cell9_controller_f_i_put n9499 NAND2XLTS
XU853 n3919 fifo_to_fft_fifo_cell8_controller_f_i_put n9499 NAND2XLTS
XU863 n3929 fifo_to_fft_fifo_cell6_controller_f_i_put n9499 NAND2XLTS
XU823 n3889 fifo_to_fft_fifo_cell14_controller_f_i_put n9498 NAND2XLTS
XU1628 n4517 fifo_from_fft_fifo_cell11_controller_f_i_put n9507 NAND2XLTS
XU1517 n4499 fifo_from_fft_fifo_cell14_controller_f_i_put n9506 NAND2XLTS
XU1554 n4505 fifo_from_fft_fifo_cell13_controller_f_i_put n9507 NAND2XLTS
XU1665 n4523 fifo_from_fft_fifo_cell10_controller_f_i_put n9504 NAND2XLTS
XU1480 n4493 fifo_from_fft_fifo_cell15_controller_f_i_put n9506 NAND2XLTS
XU1591 n4511 fifo_from_fft_fifo_cell12_controller_f_i_put n9506 NAND2XLTS
XU858 n3924 fifo_to_fft_fifo_cell7_controller_f_i_put n9500 NAND2XLTS
XU2185 n4691 fifo_from_fir_fifo_cell13_controller_f_i_put n9505 NAND2XLTS
XU962 n4059 fifo_to_fir_fifo_cell15_controller_f_i_put n9502 NAND2XLTS
XU967 n4064 fifo_to_fir_fifo_cell14_controller_f_i_put n9502 NAND2X1TS
XU972 n4069 fifo_to_fir_fifo_cell13_controller_f_i_put n9502 NAND2XLTS
XU977 n4074 fifo_to_fir_fifo_cell12_controller_f_i_put n9502 NAND2XLTS
XU868 n3934 fifo_to_fft_fifo_cell5_controller_f_i_put n9500 NAND2XLTS
XU982 n4079 fifo_to_fir_fifo_cell11_controller_f_i_put n9503 NAND2XLTS
XU987 n4084 fifo_to_fir_fifo_cell10_controller_f_i_put n9501 NAND2XLTS
XU873 n3939 fifo_to_fft_fifo_cell4_controller_f_i_put n9500 NAND2XLTS
XU1428 n4205 FE_OFN843_n7619 acc_done NOR2X1TS
XU992 n4089 fifo_to_fir_fifo_cell9_controller_f_i_put n9503 NAND2XLTS
XU997 n4094 fifo_to_fir_fifo_cell8_controller_f_i_put n9503 NAND2XLTS
XU1002 n4099 fifo_to_fir_fifo_cell7_controller_f_i_put n9504 NAND2XLTS
XU878 n3944 fifo_to_fft_fifo_cell3_controller_f_i_put n9501 NAND2XLTS
XU1007 n4104 fifo_to_fir_fifo_cell6_controller_f_i_put n9503 NAND2XLTS
XU883 n3949 fifo_to_fft_fifo_cell2_controller_f_i_put n9501 NAND2XLTS
XU1012 n4109 fifo_to_fir_fifo_cell5_controller_f_i_put n9505 NAND2XLTS
XU1017 n4114 fifo_to_fir_fifo_cell4_controller_f_i_put n9504 NAND2XLTS
XU1022 n4119 fifo_to_fir_fifo_cell3_controller_f_i_put n9505 NAND2XLTS
XU888 n3954 fifo_to_fft_fifo_cell1_controller_f_i_put n9501 NAND2XLTS
XU895 n3960 fifo_to_fft_fifo_cell0_controller_f_i_put n9500 NAND2XLTS
XU1027 n4124 fifo_to_fir_fifo_cell2_controller_f_i_put n9505 NAND2XLTS
XU1032 n4129 fifo_to_fir_fifo_cell1_controller_f_i_put n9506 NAND2XLTS
XU1039 n4135 fifo_to_fir_fifo_cell0_controller_f_i_put n9504 NAND2XLTS
XU1813 n4547 fifo_from_fft_fifo_cell6_controller_f_i_put n9507 NAND2XLTS
XU1739 n4535 fifo_from_fft_fifo_cell8_controller_f_i_put n9507 NAND2XLTS
XU3322 n4444 n4311 FE_OFN843_n7619 NOR2X1TS
XU1437 n4455 n3846 CLKINVX2TS
XU1438 n4203 n4456 INVX1TS
XU1961 n4571 fifo_from_fft_fifo_cell2_controller_f_i_put n9508 NAND2XLTS
XU1776 n4541 fifo_from_fft_fifo_cell7_controller_f_i_put n9509 NAND2XLTS
XU2653 n4765 fifo_from_fir_fifo_cell0_controller_f_i_put n9511 NAND2XLTS
XU1998 n4577 fifo_from_fft_fifo_cell1_controller_f_i_put n9510 NAND2XLTS
XU1887 n4559 fifo_from_fft_fifo_cell4_controller_f_i_put n9508 NAND2XLTS
XU2111 n4679 fifo_from_fir_fifo_cell15_controller_f_i_put n9511 NAND2XLTS
XU3445 n5191 FE_OFN1450_acc_fir_get n9514 n3471 NAND3X1TS
XU2629 n4763 fifo_from_fir_fifo_cell1_controller_f_i_put n9513 NAND2XLTS
XU1924 n4565 fifo_from_fft_fifo_cell3_controller_f_i_put n9510 NAND2XLTS
XU3589 n5233 FE_OFN1448_acc_fft_get n9514 n3482 NAND3X2TS
XU2022 n4579 fifo_from_fft_fifo_cell0_controller_f_i_put n9508 NAND2XLTS
XU1850 n4553 fifo_from_fft_fifo_cell5_controller_f_i_put n9509 NAND2XLTS
XU2259 n4703 fifo_from_fir_fifo_cell11_controller_f_i_put n9512 NAND2XLTS
XU2407 n4727 fifo_from_fir_fifo_cell7_controller_f_i_put n9512 NAND2XLTS
XU2370 n4721 fifo_from_fir_fifo_cell8_controller_f_i_put n9511 NAND2XLTS
XU2444 n4733 fifo_from_fir_fifo_cell6_controller_f_i_put n9510 NAND2XLTS
XU2296 n4709 fifo_from_fir_fifo_cell10_controller_f_i_put n9509 NAND2XLTS
XU2222 n4697 fifo_from_fir_fifo_cell12_controller_f_i_put n9510 NAND2XLTS
XU2481 n4739 fifo_from_fir_fifo_cell5_controller_f_i_put n9513 NAND2XLTS
XU2518 n4745 fifo_from_fir_fifo_cell4_controller_f_i_put n9511 NAND2XLTS
XU2592 n4757 fifo_from_fir_fifo_cell2_controller_f_i_put n9512 NAND2XLTS
XU3870 n4643 FE_OFN795_n7619 from_fft_empty n5346 NOR3X1TS
XU2148 n4685 fifo_from_fir_fifo_cell14_controller_f_i_put n9509 NAND2XLTS
XU2555 n4751 fifo_from_fir_fifo_cell3_controller_f_i_put n9513 NAND2XLTS
XU1702 n4529 fifo_from_fft_fifo_cell9_controller_f_i_put n9508 NAND2XLTS
XU2333 n4715 fifo_from_fir_fifo_cell9_controller_f_i_put n9512 NAND2XLTS
XU606 FE_OFN848_ram_write_enable n3705 n3706 n3707 AOI21X1TS
XU1432 n4454 FE_OFN1283_router_fft_write_done n7960 n4455 NAND3XLTS
XU3474 fifo_to_fft_fifo_cell15_N7 fifo_to_fft_fifo_cell15_reg_gtok_token
+ fifo_to_fft_fifo_cell15_control_signal n5233 NOR3BXLTS
XU3444 n4134 n5191 CLKINVX2TS
XU3588 n3959 n5233 INVX2TS
XU3331 fifo_to_fir_fifo_cell15_N7 fifo_to_fir_fifo_cell15_reg_gtok_token
+ fifo_to_fir_fifo_cell15_control_signal n5191 NOR3BXLTS
XU3815 n5326 n7524 fifo_from_fft_fifo_cell1_controller_write_enable
+ fifo_from_fft_fifo_cell1_controller_valid_read NOR3X1TS
XU1431 n4453 n4025 n7212 n4200 n4454 OAI31XLTS
XU1104 n4201 n4202 n3846 NAND2XLTS
XU810 n3847 n3848 n9434 n9480 n3849 NAND4BXLTS
XU227 n3480 n3472 n7607 NOR2XLTS
XU217 n3463 n7203 n3467 NAND2XLTS
XU1422 n4442 mips_mips_a_count[0] mips_mips_a_countflag NAND2XLTS
XU3726 n4764 FE_OFN735_n4829 fifo_from_fir_fifo_cell0_reg_gtok_token NAND2X1TS
XU3782 n5318 n7485 fifo_from_fft_fifo_cell9_controller_write_enable
+ fifo_from_fft_fifo_cell9_controller_valid_read NOR3X1TS
XU3766 n5314 n7465 fifo_from_fft_fifo_cell13_controller_write_enable
+ fifo_from_fft_fifo_cell13_controller_valid_read NOR3X1TS
XU3774 n5316 n7475 fifo_from_fft_fifo_cell11_controller_write_enable
+ fifo_from_fft_fifo_cell11_controller_valid_read NOR3X1TS
XU3762 n5313 n7460 fifo_from_fft_fifo_cell14_controller_write_enable
+ fifo_from_fft_fifo_cell14_controller_valid_read NOR3X1TS
XU3770 n5315 n7470 fifo_from_fft_fifo_cell12_controller_write_enable
+ fifo_from_fft_fifo_cell12_controller_valid_read NOR3X1TS
XU3837 n4500 FE_OFN723_n4643 fifo_from_fft_fifo_cell13_reg_gtok_token NAND2XLTS
XU3843 n4494 FE_OFN725_n4643 fifo_from_fft_fifo_cell14_reg_gtok_token NAND2XLTS
XU3794 n5321 n7499 fifo_from_fft_fifo_cell6_controller_write_enable
+ fifo_from_fft_fifo_cell6_controller_valid_read NOR3X1TS
XU3639 n5279 n7559 fifo_from_fir_fifo_cell9_controller_write_enable
+ fifo_from_fir_fifo_cell9_controller_valid_read NOR3X1TS
XU3635 n5278 n7554 fifo_from_fir_fifo_cell10_controller_write_enable
+ fifo_from_fir_fifo_cell10_controller_valid_read NOR3X1TS
XU3651 n5282 n7574 fifo_from_fir_fifo_cell6_controller_write_enable
+ fifo_from_fir_fifo_cell6_controller_valid_read NOR3X1TS
XU3790 n5320 n7494 fifo_from_fft_fifo_cell7_controller_write_enable
+ fifo_from_fft_fifo_cell7_controller_valid_read NOR3X1TS
XU3619 n5274 n7534 fifo_from_fir_fifo_cell14_controller_write_enable
+ fifo_from_fir_fifo_cell14_controller_valid_read NOR3X1TS
XU3647 n5281 n7569 fifo_from_fir_fifo_cell7_controller_write_enable
+ fifo_from_fir_fifo_cell7_controller_valid_read NOR3X1TS
XU3802 n5323 n7509 fifo_from_fft_fifo_cell4_controller_write_enable
+ fifo_from_fft_fifo_cell4_controller_valid_read NOR3X1TS
XU3623 n5275 n7539 fifo_from_fir_fifo_cell13_controller_write_enable
+ fifo_from_fir_fifo_cell13_controller_valid_read NOR3X1TS
XU3627 n5276 n7544 fifo_from_fir_fifo_cell12_controller_write_enable
+ fifo_from_fir_fifo_cell12_controller_valid_read NOR3X1TS
XU3655 n5283 n7579 fifo_from_fir_fifo_cell5_controller_write_enable
+ fifo_from_fir_fifo_cell5_controller_valid_read NOR3X1TS
XU3659 n5284 n7584 fifo_from_fir_fifo_cell4_controller_write_enable
+ fifo_from_fir_fifo_cell4_controller_valid_read NOR3X1TS
XU3663 n5285 n7589 fifo_from_fir_fifo_cell3_controller_write_enable
+ fifo_from_fir_fifo_cell3_controller_valid_read NOR3X1TS
XU3806 n5324 n7514 fifo_from_fft_fifo_cell3_controller_write_enable
+ fifo_from_fft_fifo_cell3_controller_valid_read NOR3X1TS
XU3798 n5322 n7504 fifo_from_fft_fifo_cell5_controller_write_enable
+ fifo_from_fft_fifo_cell5_controller_valid_read NOR3X1TS
XU3672 n5287 n7599 fifo_from_fir_fifo_cell1_controller_write_enable
+ fifo_from_fir_fifo_cell1_controller_valid_read NOR3X1TS
XU3631 n5277 n7549 fifo_from_fir_fifo_cell11_controller_write_enable
+ fifo_from_fir_fifo_cell11_controller_valid_read NOR3X1TS
XU3778 n5317 n7480 fifo_from_fft_fifo_cell10_controller_write_enable
+ fifo_from_fft_fifo_cell10_controller_valid_read NOR3X1TS
XU3667 n5286 n7594 fifo_from_fir_fifo_cell2_controller_write_enable
+ fifo_from_fir_fifo_cell2_controller_valid_read NOR3X1TS
XU3694 n4686 FE_OFN742_n4829 fifo_from_fir_fifo_cell13_reg_gtok_token NAND2XLTS
XU3700 n4680 FE_OFN742_n4829 fifo_from_fir_fifo_cell14_reg_gtok_token NAND2X1TS
XU2693 n6754 fifo_from_fir_fifo_cell6_reg_gtok_token n7966 n4734 OAI2BB1XLTS
XU2694 n6755 fifo_from_fir_fifo_cell5_reg_gtok_token n7966 n4740 OAI2BB1XLTS
XU2695 n6756 fifo_from_fir_fifo_cell4_reg_gtok_token n7965 n4746 OAI2BB1XLTS
XU2698 n6759 fifo_from_fir_fifo_cell1_reg_gtok_token n7963 n4764 OAI2BB1XLTS
XU2061 n6224 fifo_from_fft_fifo_cell7_reg_gtok_token n7970 n4542 OAI2BB1XLTS
XU2063 n6226 fifo_from_fft_fifo_cell5_reg_gtok_token n7971 n4554 OAI2BB1XLTS
XU2064 n6227 fifo_from_fft_fifo_cell4_reg_gtok_token n7969 n4560 OAI2BB1XLTS
XU2060 n6223 fifo_from_fft_fifo_cell8_reg_gtok_token n7971 n4536 OAI2BB1XLTS
XU2065 n6228 fifo_from_fft_fifo_cell3_reg_gtok_token n7968 n4566 OAI2BB1XLTS
XU2066 n6229 fifo_from_fft_fifo_cell2_reg_gtok_token n7971 n4572 OAI2BB1XLTS
XU2059 n6222 fifo_from_fft_fifo_cell9_reg_gtok_token n7969 n4530 OAI2BB1XLTS
XU2067 n6230 fifo_from_fft_fifo_cell1_reg_gtok_token n7968 n4578 OAI2BB1XLTS
XU2058 n6221 fifo_from_fft_fifo_cell10_reg_gtok_token n7970 n4524 OAI2BB1XLTS
XU2057 n6220 fifo_from_fft_fifo_cell11_reg_gtok_token n7971 n4518 OAI2BB1XLTS
XU2056 n6219 fifo_from_fft_fifo_cell12_reg_gtok_token n7968 n4512 OAI2BB1XLTS
XU2054 n6217 fifo_from_fft_fifo_cell14_reg_gtok_token n7970 n4500 OAI2BB1XLTS
XU2053 n6216 fifo_from_fft_fifo_cell15_reg_gtok_token n7970 n4494 OAI2BB1XLTS
XU2055 n6218 fifo_from_fft_fifo_cell13_reg_gtok_token n7969 n4506 OAI2BB1XLTS
XU2062 n6225 fifo_from_fft_fifo_cell6_reg_gtok_token n7969 n4548 OAI2BB1XLTS
XU2697 n6758 fifo_from_fir_fifo_cell2_reg_gtok_token n7964 n4758 OAI2BB1XLTS
XU2696 n6757 fifo_from_fir_fifo_cell3_reg_gtok_token n7964 n4752 OAI2BB1XLTS
XU2692 n6753 fifo_from_fir_fifo_cell7_reg_gtok_token n7965 n4728 OAI2BB1XLTS
XU1420 n5700 n4441 n4442 n4443 AOI21X1TS
XU2691 n6752 fifo_from_fir_fifo_cell8_reg_gtok_token n7965 n4722 OAI2BB1XLTS
XU2690 n6751 fifo_from_fir_fifo_cell9_reg_gtok_token n7964 n4716 OAI2BB1XLTS
XU2689 n6750 fifo_from_fir_fifo_cell10_reg_gtok_token n7966 n4710 OAI2BB1XLTS
XU2688 n6749 fifo_from_fir_fifo_cell11_reg_gtok_token n7966 n4704 OAI2BB1XLTS
XU2687 n6748 fifo_from_fir_fifo_cell12_reg_gtok_token n7963 n4698 OAI2BB1XLTS
XU2686 n6747 fifo_from_fir_fifo_cell13_reg_gtok_token n7963 n4692 OAI2BB1XLTS
XU2685 n6746 fifo_from_fir_fifo_cell14_reg_gtok_token n7964 n4686 OAI2BB1XLTS
XU2684 n6745 fifo_from_fir_fifo_cell15_reg_gtok_token n7965 n4680 OAI2BB1XLTS
XU3323 from_fir_full n3465 INVX2TS
XU3414 n5219 fifo_to_fir_fifo_cell6_data_out_N35
+ fifo_to_fir_fifo_cell5_data_out_N35 n4108 n4103 AOI22XLTS
XU795 n3476 n3484 CLKINVX1TS
XU3558 n5261 fifo_to_fft_fifo_cell6_data_out_N35
+ fifo_to_fft_fifo_cell5_data_out_N35 n3933 n3928 AOI22XLTS
XU2721 n3835 router_data_cntl_fft_full_flag n3484 NAND2XLTS
XU230 n3483 n3484 n3477 NAND2XLTS
XU3434 n4058 fifo_to_fir_fifo_cell14_reg_gtok_token FE_OFN684_n4134 AND2XLTS
XU3443 n4128 fifo_to_fir_fifo_cell0_reg_gtok_token FE_OFN683_n4134 AND2XLTS
XU3578 n3883 fifo_to_fft_fifo_cell14_reg_gtok_token n3959 AND2XLTS
XU3324 from_fft_full n3477 INVX2TS
XU3587 n3953 fifo_to_fft_fifo_cell0_reg_gtok_token FE_OFN700_n3959 AND2XLTS
XU1423 n5701 n9370 mips_mips_a_count[0] mips_mips_a_N49 n4445 n8051 OAI32XLTS
XU794 n3830 n3834 n3835 NOR2BXLTS
XU226 n3481 n3482 n9433 FE_OFN1217_n3478 n3483 n9433 AOI32XLTS
XU3409 n5220 fifo_to_fir_fifo_cell4_data_out_N35
+ fifo_to_fir_fifo_cell3_data_out_N35 n4118 n4113 AOI22XLTS
XU821 n5472 fifo_to_fft_fifo_cell14_reg_gtok_token n7974 n3888 OAI2BB1XLTS
XU3437 n5225 fifo_to_fir_fifo_cell12_data_out_N35
+ fifo_to_fir_fifo_cell11_data_out_N35 n4078 n4073 AOI22XLTS
XU228 n3479 router_data_cntl_N135 INVX1TS
XU3426 n5223 fifo_to_fir_fifo_cell7_data_out_N35
+ fifo_to_fir_fifo_cell14_data_out_N35 n4063 n4098 AOI22XLTS
XU178 n2848 n3830 CLKINVX1TS
XU3421 n5224 fifo_to_fir_fifo_cell9_data_out_N35
+ fifo_to_fir_fifo_cell8_data_out_N35 n4093 n4088 AOI22XLTS
XU846 n5487 fifo_to_fft_fifo_cell9_reg_gtok_token n7974 n3913 OAI2BB1XLTS
XU798 n3837 router_data_cntl_fir_full_flag n7608 NAND2XLTS
XU3565 n5266 fifo_to_fft_fifo_cell9_data_out_N35
+ fifo_to_fft_fifo_cell8_data_out_N35 n3918 n3913 AOI22XLTS
XU841 n5484 fifo_to_fft_fifo_cell10_reg_gtok_token n7976 n3908 OAI2BB1XLTS
XU222 n3473 n7609 n3465 NAND2XLTS
XU881 n5508 fifo_to_fft_fifo_cell2_reg_gtok_token n7974 n3948 OAI2BB1XLTS
XU831 n5478 fifo_to_fft_fifo_cell12_reg_gtok_token n7973 n3898 OAI2BB1XLTS
XU826 n5475 fifo_to_fft_fifo_cell13_reg_gtok_token n7973 n3893 OAI2BB1XLTS
XU851 n5490 fifo_to_fft_fifo_cell8_reg_gtok_token n7975 n3918 OAI2BB1XLTS
XU3581 n5267 fifo_to_fft_fifo_cell12_data_out_N35
+ fifo_to_fft_fifo_cell11_data_out_N35 n3903 n3898 AOI22XLTS
XU856 n5493 fifo_to_fft_fifo_cell7_reg_gtok_token n7975 n3923 OAI2BB1XLTS
XU3570 n5265 fifo_to_fft_fifo_cell7_data_out_N35
+ fifo_to_fft_fifo_cell14_data_out_N35 n3888 n3923 AOI22XLTS
XU866 n5499 fifo_to_fft_fifo_cell5_reg_gtok_token n7976 n3933 OAI2BB1XLTS
XU836 n5481 fifo_to_fft_fifo_cell11_reg_gtok_token n7976 n3903 OAI2BB1XLTS
XU3553 n5262 fifo_to_fft_fifo_cell4_data_out_N35
+ fifo_to_fft_fifo_cell3_data_out_N35 n3943 n3938 AOI22XLTS
XU876 n5505 fifo_to_fft_fifo_cell3_reg_gtok_token n7974 n3943 OAI2BB1XLTS
XU871 n5502 fifo_to_fft_fifo_cell4_reg_gtok_token n7975 n3938 OAI2BB1XLTS
XU861 n5496 fifo_to_fft_fifo_cell6_reg_gtok_token n7976 n3928 OAI2BB1XLTS
XU1010 n5551 fifo_to_fir_fifo_cell5_reg_gtok_token n7615 n4108 OAI2BB1XLTS
XU985 n5536 fifo_to_fir_fifo_cell10_reg_gtok_token n7614 n4083 OAI2BB1XLTS
XU1025 n5560 fifo_to_fir_fifo_cell2_reg_gtok_token n7614 n4123 OAI2BB1XLTS
XU1005 n5548 fifo_to_fir_fifo_cell6_reg_gtok_token n7614 n4103 OAI2BB1XLTS
XU886 n5511 fifo_to_fft_fifo_cell1_reg_gtok_token n7973 n7335 OAI2BB1XLTS
XU1000 n5545 fifo_to_fir_fifo_cell7_reg_gtok_token n7617 n4098 OAI2BB1XLTS
XU3577 fifo_to_fft_fifo_cell15_data_out_N35 n7236 CLKINVX1TS
XU970 n5527 fifo_to_fir_fifo_cell13_reg_gtok_token n7615 n4068 OAI2BB1XLTS
XU1030 n5563 fifo_to_fir_fifo_cell1_reg_gtok_token n7615 n7444 OAI2BB1XLTS
XU990 n5539 fifo_to_fir_fifo_cell9_reg_gtok_token n7615 n4088 OAI2BB1XLTS
XU1020 n5557 fifo_to_fir_fifo_cell3_reg_gtok_token n7617 n4118 OAI2BB1XLTS
XU995 n5542 fifo_to_fir_fifo_cell8_reg_gtok_token n7616 n4093 OAI2BB1XLTS
XU1015 n5554 fifo_to_fir_fifo_cell4_reg_gtok_token n7616 n4113 OAI2BB1XLTS
XU797 n3825 n3837 n3838 NOR2XLTS
XU221 n3468 n3471 n7203 n3467 n3473 n7203 AOI32XLTS
XU965 n5524 fifo_to_fir_fifo_cell14_reg_gtok_token n7614 n4063 OAI2BB1XLTS
XU980 n5533 fifo_to_fir_fifo_cell11_reg_gtok_token n7617 n4078 OAI2BB1XLTS
XU975 n5530 fifo_to_fir_fifo_cell12_reg_gtok_token n7616 n4073 OAI2BB1XLTS
XU960 n5521 fifo_to_fir_fifo_cell15_reg_gtok_token n7617 n7345 OAI2BB1XLTS
XU3433 fifo_to_fir_fifo_cell15_data_out_N35 n7345 CLKINVX1TS
XU816 n5469 fifo_to_fft_fifo_cell15_reg_gtok_token n7975 n7236 OAI2BB1XLTS
XU2718 n3829 router_data_cntl_N151 n3839 NOR2X1TS
XU3576 n5268 fifo_to_fft_fifo_cell10_data_out_N35
+ fifo_to_fft_fifo_cell15_data_out_N35 n7237 n3908 AOI22XLTS
XU3547 n5260 fifo_to_fft_fifo_cell1_data_out_N35
+ fifo_to_fft_fifo_cell13_data_out_N35 n3893 n7336 AOI22XLTS
XU3403 n5218 fifo_to_fir_fifo_cell1_data_out_N35
+ fifo_to_fir_fifo_cell13_data_out_N35 n4068 n7445 AOI22XLTS
XU3432 n5226 fifo_to_fir_fifo_cell10_data_out_N35
+ fifo_to_fir_fifo_cell15_data_out_N35 n7346 n4083 AOI22XLTS
XU219 n3469 router_data_cntl_N137 n3470 n9432 n7606 AOI211XLTS
XU290 n3516 FE_OFN1825_n7107 FE_OFN942_n3486 FE_OFN938_n3487
+ router_addr_calc_iir_write_calc_counter_N48 AOI22X1TS
XU294 n3518 router_addr_calc_iir_write_calc_count[0] FE_OFN945_n3486
+ FE_OFN937_n3487 n7959 AOI22X1TS
XU286 n3514 n7095 FE_OFN942_n3486 FE_OFN939_n3487
+ router_addr_calc_iir_write_calc_counter_N50 AOI22X1TS
XU280 n3511 n7092 FE_OFN947_n3486 FE_OFN937_n3487
+ router_addr_calc_iir_write_calc_counter_N53 AOI22X1TS
XU282 n3512 n7089 FE_OFN945_n3486 FE_OFN937_n3487
+ router_addr_calc_iir_write_calc_counter_N52 AOI22X1TS
XU292 n3517 n7112 FE_OFN945_n3486 FE_OFN938_n3487
+ router_addr_calc_iir_write_calc_counter_N47 AOI22X1TS
XU266 n3504 n7126 FE_OFN949_n3486 FE_OFN934_n3487
+ router_addr_calc_iir_write_calc_counter_N60 AOI22X1TS
XU268 n3505 n7121 FE_OFN949_n3486 FE_OFN935_n3487
+ router_addr_calc_iir_write_calc_counter_N59 AOI22X1TS
XU284 n3513 FE_OFN1281_router_addr_calc_iir_write_calc_count_5_ FE_OFN940_n3486
+ FE_OFN939_n3487 router_addr_calc_iir_write_calc_counter_N51 AOI22X1TS
XU2068 n6231 fifo_from_fft_fifo_cell0_reg_gtok_token n7968 n4580 OAI2BB1XLTS
XU790 n3827 n3829 FE_OFN976_n9462 FE_OFN988_n9431 n9391 AND4XLTS
XU3825 fifo_from_fft_fifo_cell0_data_out_N35 n4580 INVX1TS
XU2699 n6760 fifo_from_fir_fifo_cell0_reg_gtok_token n7963 n4766 OAI2BB1XLTS
XU273 router_addr_calc_iir_write_calc_counter_N188 FE_OFN1298_iir_enable n3508
+ NAND2XLTS
XU2071 n3758 router_data_to_fft n3840 n3755 NOR3X1TS
XU3682 fifo_from_fir_fifo_cell0_data_out_N35 n4766 INVX1TS
XU264 n3503 n7132 FE_OFN949_n3486 FE_OFN934_n3487
+ router_addr_calc_iir_write_calc_counter_N61 AOI22X1TS
XU271 router_addr_calc_iir_write_calc_counter_N189 FE_OFN1298_iir_enable n3507
+ NAND2XLTS
XU269 router_addr_calc_iir_write_calc_counter_N190 FE_OFN1294_iir_enable n3506
+ NAND2XLTS
XU287 router_addr_calc_iir_write_calc_counter_N181 FE_OFN1300_iir_enable n3515
+ NAND2XLTS
XU277 router_addr_calc_iir_write_calc_counter_N186 FE_OFN1299_iir_enable n3510
+ NAND2XLTS
XU275 router_addr_calc_iir_write_calc_counter_N187 FE_OFN1298_iir_enable n3509
+ NAND2XLTS
XU791 n3831 FE_OFN979_n9462 n7611 n3476 n3832 OAI31XLTS
XU2704 n6762 router_iir_get_req_reg n4832 n3757 AO21XLTS
XU2070 n6232 router_ram_read_enable_reg router_fft_get_req_reg n3758 AO21XLTS
XU262 n3502 FE_OFN1441_router_addr_calc_iir_write_calc_count_16_
+ FE_OFN950_n3486 FE_OFN934_n3487 router_addr_calc_iir_write_calc_counter_N62
+ AOI22X1TS
XU2628 n4761 n7599 n4764 FE_OFN666_n4759 OAI21X1TS
XU1997 n4575 n7524 n4578 n4573 OAI21XLTS
XU808 n3845 router_data_from_fir n3843 NAND2XLTS
XU807 n3844 n9406 router_data_from_fir router_data_to_fir FE_OFN978_n9462
+ NAND4XLTS
XU260 n3501 n7138 FE_OFN950_n3486 FE_OFN932_n3487
+ router_addr_calc_iir_write_calc_counter_N63 AOI22X1TS
XU2618 n6735 FE_OFN668_n4759 FE_OFN1774_acc_fir_data_in_6_ FE_OFN345_n4760
+ fifo_from_fir_fifo_cell1_sr_out[6] AO22XLTS
XU3399 n4133 fifo_to_fir_fifo_cell15_reg_gtok_token n5213 FE_OFN683_n4134
+ OAI21X1TS
XU1996 n6214 fifo_from_fft_fifo_cell1_data_out_N35 n4577 n4575 OAI21XLTS
XU2626 n6742 fifo_from_fir_fifo_cell1_controller_valid_read n4761
+ FE_OFN821_n7619 AOI21X1TS
XU2627 n6743 fifo_from_fir_fifo_cell1_data_out_N35 n4763 n4761 OAI21XLTS
XU1995 n6213 fifo_from_fft_fifo_cell1_controller_valid_read n4575
+ FE_OFN791_n7619 AOI21X1TS
XU1987 n6206 FE_OFN330_n4573 FE_OFN1589_acc_fft_data_in_6_ FE_OFN9_n4574
+ fifo_from_fft_fifo_cell1_sr_out[6] AO22XLTS
XU2051 n4459 FE_OFN327_n4573 n4460 n4640 NAND3XLTS
XU2682 n4645 FE_OFN666_n4759 n4646 n4826 NAND3XLTS
XU3543 n3958 fifo_to_fft_fifo_cell15_reg_gtok_token n5255 FE_OFN700_n3959
+ OAI21X1TS
XU805 n3842 n3844 INVXLTS
XU258 n3500 n7144 FE_OFN950_n3486 FE_OFN932_n3487
+ router_addr_calc_iir_write_calc_counter_N64 AOI22X1TS
XU2701 n6761 n4830 n7603 n3756 OAI21XLTS
XU2623 n6740 FE_OFN671_n4759 FE_OFN1804_acc_fir_data_in_1_ FE_OFN340_n4760
+ fifo_from_fir_fifo_cell1_sr_out[1] AO22XLTS
XU2624 n6741 FE_OFN671_n4759 FE_OFN1814_acc_fir_data_in_0_ FE_OFN338_n4760
+ fifo_from_fir_fifo_cell1_sr_out[0] AO22XLTS
XU2622 n6739 FE_OFN670_n4759 FE_OFN1797_acc_fir_data_in_2_ FE_OFN338_n4760
+ fifo_from_fir_fifo_cell1_sr_out[2] AO22XLTS
XU3523 n4001 n3855 INVX1TS
XU2621 n6738 FE_OFN671_n4759 FE_OFN1794_acc_fir_data_in_3_ FE_OFN340_n4760
+ fifo_from_fir_fifo_cell1_sr_out[3] AO22XLTS
XU2620 n6737 FE_OFN670_n4759 FE_OFN1789_acc_fir_data_in_4_ FE_OFN342_n4760
+ fifo_from_fir_fifo_cell1_sr_out[4] AO22XLTS
XU2619 n6736 FE_OFN668_n4759 FE_OFN1777_acc_fir_data_in_5_ FE_OFN342_n4760
+ fifo_from_fir_fifo_cell1_sr_out[5] AO22XLTS
XU2617 n6734 FE_OFN670_n4759 FE_OFN1767_acc_fir_data_in_7_ FE_OFN342_n4760
+ fifo_from_fir_fifo_cell1_sr_out[7] AO22XLTS
XU2595 n6712 FE_OFN669_n4759 FE_OFN1645_acc_fir_data_in_29_ FE_OFN348_n4760
+ fifo_from_fir_fifo_cell1_sr_out[29] AO22XLTS
XU2594 n6711 FE_OFN669_n4759 FE_OFN1637_acc_fir_data_in_30_ FE_OFN348_n4760
+ fifo_from_fir_fifo_cell1_sr_out[30] AO22XLTS
XU2593 n6710 FE_OFN669_n4759 FE_OFN1632_acc_fir_data_in_31_ FE_OFN348_n4760
+ fifo_from_fir_fifo_cell1_sr_out[31] AO22XLTS
XU891 n5514 fifo_to_fft_fifo_cell0_reg_gtok_token n7973 n3958 OAI2BB1XLTS
XU2683 n4825 n8877 n4827 fifo_from_fir_hang[0] n9465 OAI211XLTS
XU1989 n6208 FE_OFN330_n4573 FE_OFN1597_acc_fft_data_in_4_ FE_OFN9_n4574
+ fifo_from_fft_fifo_cell1_sr_out[4] AO22XLTS
XU1988 n6207 FE_OFN335_n4573 FE_OFN1594_acc_fft_data_in_5_ FE_OFN1_n4574
+ fifo_from_fft_fifo_cell1_sr_out[5] AO22XLTS
XU2052 n4639 n8844 n4641 fifo_from_fft_hang[0] n9469 OAI211XLTS
XU1991 n6210 FE_OFN336_n4573 FE_OFN1609_acc_fft_data_in_2_ FE_OFN0_n4574
+ fifo_from_fft_fifo_cell1_sr_out[2] AO22XLTS
XU1992 n6211 FE_OFN336_n4573 FE_OFN1616_acc_fft_data_in_1_ FE_OFN0_n4574
+ fifo_from_fft_fifo_cell1_sr_out[1] AO22XLTS
XU1993 n6212 FE_OFN334_n4573 FE_OFN1622_acc_fft_data_in_0_ FE_OFN2_n4574
+ fifo_from_fft_fifo_cell1_sr_out[0] AO22XLTS
XU1986 n6205 FE_OFN337_n4573 FE_OFN1584_acc_fft_data_in_7_ FE_OFN0_n4574
+ fifo_from_fft_fifo_cell1_sr_out[7] AO22XLTS
XU922 n3854 n3952 n3855 n4000 NAND3XLTS
XU1066 n4029 n4127 n4030 n4175 NAND3XLTS
XU1964 n6183 FE_OFN334_n4573 FE_OFN1465_acc_fft_data_in_29_ FE_OFN2_n4574
+ fifo_from_fft_fifo_cell1_sr_out[29] AO22XLTS
XU1963 n6182 FE_OFN334_n4573 FE_OFN1458_acc_fft_data_in_30_ FE_OFN3_n4574
+ fifo_from_fft_fifo_cell1_sr_out[30] AO22XLTS
XU1962 n6181 FE_OFN333_n4573 FE_OFN1452_acc_fft_data_in_31_ FE_OFN3_n4574
+ fifo_from_fft_fifo_cell1_sr_out[31] AO22XLTS
XU1990 n6209 FE_OFN335_n4573 FE_OFN1603_acc_fft_data_in_3_ FE_OFN2_n4574
+ fifo_from_fft_fifo_cell1_sr_out[3] AO22XLTS
XU1035 n5566 fifo_to_fir_fifo_cell0_reg_gtok_token n7616 n4133 OAI2BB1XLTS
XU256 n3499 FE_OFN1440_router_addr_calc_iir_write_calc_count_19_
+ FE_OFN950_n3486 FE_OFN932_n3487 router_addr_calc_iir_write_calc_counter_N65
+ AOI22X1TS
XU1965 n6184 FE_OFN333_n4573 FE_OFN1821_acc_fft_data_in_28_ FE_OFN3_n4574
+ fifo_from_fft_fifo_cell1_sr_out[28] AO22XLTS
XU923 n3999 n8812 n4001 fifo_to_fft_hang[1] n9477 OAI211XLTS
XU2596 n6713 FE_OFN669_n4759 FE_OFN1650_acc_fir_data_in_28_ FE_OFN348_n4760
+ fifo_from_fir_fifo_cell1_sr_out[28] AO22XLTS
XU254 n3498 n7150 FE_OFN946_n3486 FE_OFN931_n3487
+ router_addr_calc_iir_write_calc_counter_N66 AOI22X1TS
XU2602 n6719 FE_OFN675_n4759 FE_OFN1679_acc_fir_data_in_22_ FE_OFN344_n4760
+ fifo_from_fir_fifo_cell1_sr_out[22] AO22XLTS
XU2599 n6716 n4759 FE_OFN1665_acc_fir_data_in_25_ FE_OFN347_n4760
+ fifo_from_fir_fifo_cell1_sr_out[25] AO22XLTS
XU2601 n6718 FE_OFN674_n4759 FE_OFN1675_acc_fir_data_in_23_ FE_OFN339_n4760
+ fifo_from_fir_fifo_cell1_sr_out[23] AO22XLTS
XU2603 n6720 FE_OFN675_n4759 FE_OFN1684_acc_fir_data_in_21_ FE_OFN344_n4760
+ fifo_from_fir_fifo_cell1_sr_out[21] AO22XLTS
XU2600 n6717 n4759 FE_OFN1670_acc_fir_data_in_24_ FE_OFN347_n4760
+ fifo_from_fir_fifo_cell1_sr_out[24] AO22XLTS
XU2604 n6721 FE_OFN672_n4759 FE_OFN1691_acc_fir_data_in_20_ n4760
+ fifo_from_fir_fifo_cell1_sr_out[20] AO22XLTS
XU2605 n6722 FE_OFN673_n4759 FE_OFN1698_acc_fir_data_in_19_ FE_OFN341_n4760
+ fifo_from_fir_fifo_cell1_sr_out[19] AO22XLTS
XU2597 n6714 FE_OFN667_n4759 FE_OFN1655_acc_fir_data_in_27_ FE_OFN345_n4760
+ fifo_from_fir_fifo_cell1_sr_out[27] AO22XLTS
XU2606 n6723 FE_OFN676_n4759 FE_OFN1704_acc_fir_data_in_18_ FE_OFN346_n4760
+ fifo_from_fir_fifo_cell1_sr_out[18] AO22XLTS
XU2607 n6724 FE_OFN673_n4759 FE_OFN1708_acc_fir_data_in_17_ FE_OFN341_n4760
+ fifo_from_fir_fifo_cell1_sr_out[17] AO22XLTS
XU2598 n6715 FE_OFN667_n4759 FE_OFN1658_acc_fir_data_in_26_ FE_OFN347_n4760
+ fifo_from_fir_fifo_cell1_sr_out[26] AO22XLTS
XU2609 n6726 FE_OFN674_n4759 FE_OFN1722_acc_fir_data_in_15_ FE_OFN339_n4760
+ fifo_from_fir_fifo_cell1_sr_out[15] AO22XLTS
XU2608 n6725 FE_OFN673_n4759 FE_OFN1715_acc_fir_data_in_16_ FE_OFN341_n4760
+ fifo_from_fir_fifo_cell1_sr_out[16] AO22XLTS
XU2612 n6729 FE_OFN675_n4759 FE_OFN1737_acc_fir_data_in_12_ FE_OFN344_n4760
+ fifo_from_fir_fifo_cell1_sr_out[12] AO22XLTS
XU2613 n6730 FE_OFN677_n4759 FE_OFN1742_acc_fir_data_in_11_ FE_OFN346_n4760
+ fifo_from_fir_fifo_cell1_sr_out[11] AO22XLTS
XU2614 n6731 FE_OFN676_n4759 FE_OFN1750_acc_fir_data_in_10_ FE_OFN343_n4760
+ fifo_from_fir_fifo_cell1_sr_out[10] AO22XLTS
XU2615 n6732 FE_OFN677_n4759 FE_OFN1753_acc_fir_data_in_9_ FE_OFN346_n4760
+ fifo_from_fir_fifo_cell1_sr_out[9] AO22XLTS
XU2616 n6733 FE_OFN677_n4759 FE_OFN1758_acc_fir_data_in_8_ FE_OFN346_n4760
+ fifo_from_fir_fifo_cell1_sr_out[8] AO22XLTS
XU1980 n6199 FE_OFN329_n4573 FE_OFN1551_acc_fft_data_in_13_ FE_OFN6_n4574
+ fifo_from_fft_fifo_cell1_sr_out[13] AO22XLTS
XU1979 n6198 FE_OFN328_n4573 FE_OFN1546_acc_fft_data_in_14_ FE_OFN8_n4574
+ fifo_from_fft_fifo_cell1_sr_out[14] AO22XLTS
XU1978 n6197 FE_OFN329_n4573 FE_OFN1542_acc_fft_data_in_15_ FE_OFN7_n4574
+ fifo_from_fft_fifo_cell1_sr_out[15] AO22XLTS
XU2611 n6728 FE_OFN676_n4759 FE_OFN1734_acc_fir_data_in_13_ FE_OFN343_n4760
+ fifo_from_fir_fifo_cell1_sr_out[13] AO22XLTS
XU2610 n6727 FE_OFN675_n4759 FE_OFN1728_acc_fir_data_in_14_ FE_OFN344_n4760
+ fifo_from_fir_fifo_cell1_sr_out[14] AO22XLTS
XU1966 n6185 FE_OFN336_n4573 FE_OFN1473_acc_fft_data_in_27_ FE_OFN1_n4574
+ fifo_from_fft_fifo_cell1_sr_out[27] AO22XLTS
XU1977 n6196 FE_OFN327_n4573 FE_OFN1537_acc_fft_data_in_16_ FE_OFN9_n4574
+ fifo_from_fft_fifo_cell1_sr_out[16] AO22XLTS
XU1970 n6189 FE_OFN330_n4573 FE_OFN1494_acc_fft_data_in_23_ FE_OFN7_n4574
+ fifo_from_fft_fifo_cell1_sr_out[23] AO22XLTS
XU1968 n6187 FE_OFN337_n4573 FE_OFN1483_acc_fft_data_in_25_ n4574
+ fifo_from_fft_fifo_cell1_sr_out[25] AO22XLTS
XU1972 n6191 FE_OFN333_n4573 FE_OFN1505_acc_fft_data_in_21_ FE_OFN4_n4574
+ fifo_from_fft_fifo_cell1_sr_out[21] AO22XLTS
XU1971 n6190 FE_OFN332_n4573 FE_OFN1498_acc_fft_data_in_22_ FE_OFN4_n4574
+ fifo_from_fft_fifo_cell1_sr_out[22] AO22XLTS
XU1982 n6201 FE_OFN331_n4573 FE_OFN1560_acc_fft_data_in_11_ FE_OFN5_n4574
+ fifo_from_fft_fifo_cell1_sr_out[11] AO22XLTS
XU1983 n6202 FE_OFN332_n4573 FE_OFN1564_acc_fft_data_in_10_ FE_OFN4_n4574
+ fifo_from_fft_fifo_cell1_sr_out[10] AO22XLTS
XU1985 n6204 FE_OFN332_n4573 FE_OFN1577_acc_fft_data_in_8_ FE_OFN5_n4574
+ fifo_from_fft_fifo_cell1_sr_out[8] AO22XLTS
XU1981 n6200 FE_OFN328_n4573 FE_OFN1556_acc_fft_data_in_12_ FE_OFN8_n4574
+ fifo_from_fft_fifo_cell1_sr_out[12] AO22XLTS
XU1974 n6193 FE_OFN327_n4573 FE_OFN1515_acc_fft_data_in_19_ FE_OFN9_n4574
+ fifo_from_fft_fifo_cell1_sr_out[19] AO22XLTS
XU1973 n6192 FE_OFN331_n4573 FE_OFN1514_acc_fft_data_in_20_ FE_OFN6_n4574
+ fifo_from_fft_fifo_cell1_sr_out[20] AO22XLTS
XU1967 n6186 FE_OFN335_n4573 FE_OFN1478_acc_fft_data_in_26_ FE_OFN1_n4574
+ fifo_from_fft_fifo_cell1_sr_out[26] AO22XLTS
XU1984 n6203 FE_OFN331_n4573 FE_OFN1572_acc_fft_data_in_9_ FE_OFN5_n4574
+ fifo_from_fft_fifo_cell1_sr_out[9] AO22XLTS
XU1976 n6195 FE_OFN328_n4573 FE_OFN1530_acc_fft_data_in_17_ FE_OFN8_n4574
+ fifo_from_fft_fifo_cell1_sr_out[17] AO22XLTS
XU1975 n6194 FE_OFN330_n4573 FE_OFN1522_acc_fft_data_in_18_ FE_OFN7_n4574
+ fifo_from_fft_fifo_cell1_sr_out[18] AO22XLTS
XU1969 n6188 FE_OFN337_n4573 FE_OFN1488_acc_fft_data_in_24_ n4574
+ fifo_from_fft_fifo_cell1_sr_out[24] AO22XLTS
XU880 n3945 n7326 n3943 n3947 OAI21XLTS
XU477 n3629 FE_OFN1252_n7397 FE_OFN971_n3618 FE_OFN953_n3619
+ router_addr_calc_fft_write_calc_counter_N67 AOI22X1TS
XU553 router_addr_calc_fft_read_calc_counter_N198 n9439 n3674 NAND2XLTS
XU552 n3673 n7521 FE_OFN884_n3662 FE_OFN874_n3663
+ router_addr_calc_fft_read_calc_counter_N67 AOI22X1TS
XU252 n3497 n7156 FE_OFN946_n3486 FE_OFN931_n3487
+ router_addr_calc_iir_write_calc_counter_N67 AOI22X1TS
XU1023 n5559 fifo_to_fir_fifo_cell3_controller_valid_read n4120 FE_OFN790_n7619
+ AOI21X1TS
XU1960 n4569 n7519 n4572 n8472 OAI21XLTS
XU879 n5507 fifo_to_fft_fifo_cell3_controller_valid_read n3945 FE_OFN805_n7619
+ AOI21X1TS
XU2591 n4755 n7594 n4758 n8137 OAI21XLTS
XU1064 n4031 n4122 n4032 n4172 NAND3XLTS
XU920 n3856 n3947 n3857 n3997 NAND3XLTS
XU877 n5506 fifo_to_fft_fifo_cell3_data_out_N35 n3944 n3945 OAI21XLTS
XU562 n3678 router_addr_calc_fft_read_calc_count[16] FE_OFN886_n3662
+ FE_OFN876_n3663 router_addr_calc_fft_read_calc_counter_N62 AOI22X1TS
XU560 n3677 n7536 FE_OFN886_n3662 FE_OFN876_n3663
+ router_addr_calc_fft_read_calc_counter_N63 AOI22X1TS
XU558 n3676 n7531 FE_OFN884_n3662 FE_OFN876_n3663
+ router_addr_calc_fft_read_calc_counter_N64 AOI22X1TS
XU556 n3675 FE_OFN1258_router_addr_calc_fft_read_calc_count_19_ FE_OFN886_n3662
+ FE_OFN876_n3663 router_addr_calc_fft_read_calc_counter_N65 AOI22X1TS
XU487 n3634 n7417 FE_OFN967_n3618 FE_OFN956_n3619
+ router_addr_calc_fft_write_calc_counter_N62 AOI22X1TS
XU485 n3633 n7412 FE_OFN967_n3618 FE_OFN955_n3619
+ router_addr_calc_fft_write_calc_counter_N63 AOI22X1TS
XU483 n3632 n7407 FE_OFN968_n3618 FE_OFN955_n3619
+ router_addr_calc_fft_write_calc_counter_N64 AOI22X1TS
XU481 n3631 router_addr_calc_fft_write_calc_count[19] FE_OFN968_n3618
+ FE_OFN953_n3619 router_addr_calc_fft_write_calc_counter_N65 AOI22X1TS
XU250 n3496 n7162 FE_OFN946_n3486 FE_OFN931_n3487
+ router_addr_calc_iir_write_calc_counter_N68 AOI22X1TS
XU1065 n4171 n8790 n4173 fifo_to_fir_hang[2] n9473 OAI211XLTS
XU921 n3996 n8811 n3998 fifo_to_fft_hang[2] n9477 OAI211XLTS
XU2567 n6687 n8143 FE_OFN1694_acc_fir_data_in_20_ FE_OFN355_n4754
+ fifo_from_fir_fifo_cell2_sr_out[20] AO22XLTS
XU2680 n4647 n8137 n4648 n4823 NAND3XLTS
XU2049 n4461 n8472 n4462 n4637 NAND3XLTS
XU1934 n6156 n8478 FE_OFN1504_acc_fft_data_in_22_ FE_OFN15_n4568
+ fifo_from_fft_fifo_cell2_sr_out[22] AO22XLTS
XU2589 n6708 fifo_from_fir_fifo_cell2_controller_valid_read n4755
+ FE_OFN809_n7619 AOI21X1TS
XU1959 n6180 fifo_from_fft_fifo_cell2_data_out_N35 n4571 n4569 OAI21XLTS
XU2590 n6709 fifo_from_fir_fifo_cell2_data_out_N35 n4757 n4755 OAI21XLTS
XU1958 n6179 fifo_from_fft_fifo_cell2_controller_valid_read n4569
+ FE_OFN807_n7619 AOI21X1TS
XU495 n3638 n7432 FE_OFN967_n3618 FE_OFN956_n3619
+ router_addr_calc_fft_write_calc_counter_N58 AOI22X1TS
XU248 n3495 FE_OFN1244_router_addr_calc_iir_write_calc_count_23_
+ FE_OFN944_n3486 n3487 router_addr_calc_iir_write_calc_counter_N69 AOI22X1TS
XU582 n3688 n7581 FE_OFN882_n3662 FE_OFN867_n3663
+ router_addr_calc_fft_read_calc_counter_N52 AOI22X1TS
XU580 n3687 n7576 FE_OFN882_n3662 FE_OFN867_n3663
+ router_addr_calc_fft_read_calc_counter_N53 AOI22X1TS
XU327 n3541 FE_OFN1254_n7159 FE_OFN902_n3530 FE_OFN891_n3531
+ router_addr_calc_fir_write_calc_counter_N67 AOI22X1TS
XU511 n3646 n7467 FE_OFN963_n3618 FE_OFN960_n3619
+ router_addr_calc_fft_write_calc_counter_N50 AOI22X1TS
XU568 n3681 n7551 FE_OFN887_n3662 FE_OFN871_n3663
+ router_addr_calc_fft_read_calc_counter_N59 AOI22X1TS
XU493 n3637 n7427 FE_OFN966_n3618 FE_OFN957_n3619
+ router_addr_calc_fft_write_calc_counter_N59 AOI22X1TS
XU505 n3643 n7452 FE_OFN964_n3618 FE_OFN959_n3619
+ router_addr_calc_fft_write_calc_counter_N53 AOI22X1TS
XU549 router_addr_calc_fft_read_calc_counter_N200 n9439 n3672 NAND2XLTS
XU503 n3642 n7447 FE_OFN964_n3618 FE_OFN958_n3619
+ router_addr_calc_fft_write_calc_counter_N54 AOI22X1TS
XU566 n3680 n7546 FE_OFN887_n3662 FE_OFN871_n3663
+ router_addr_calc_fft_read_calc_counter_N60 AOI22X1TS
XU584 n3689 router_addr_calc_fft_read_calc_count[5] FE_OFN881_n3662
+ FE_OFN868_n3663 router_addr_calc_fft_read_calc_counter_N51 AOI22X1TS
XU473 n3627 router_addr_calc_fft_write_calc_count[23] FE_OFN969_n3618
+ FE_OFN951_n3619 router_addr_calc_fft_write_calc_counter_N69 AOI22X1TS
XU586 n3690 n7586 FE_OFN877_n3662 FE_OFN875_n3663
+ router_addr_calc_fft_read_calc_counter_N50 AOI22X1TS
XU548 n3671 router_addr_calc_fft_read_calc_count[23] FE_OFN883_n3662
+ FE_OFN872_n3663 router_addr_calc_fft_read_calc_counter_N69 AOI22X1TS
XU398 n3583 router_addr_calc_fir_read_calc_count[23] FE_OFN927_n3574
+ FE_OFN916_n3575 router_addr_calc_fir_read_calc_counter_N69 AOI22X1TS
XU491 n3636 n7422 FE_OFN966_n3618 FE_OFN956_n3619
+ router_addr_calc_fft_write_calc_counter_N60 AOI22X1TS
XU513 n3647 n7472 FE_OFN963_n3618 FE_OFN960_n3619
+ router_addr_calc_fft_write_calc_counter_N49 AOI22X1TS
XU570 n3682 n7556 FE_OFN887_n3662 FE_OFN871_n3663
+ router_addr_calc_fft_read_calc_counter_N58 AOI22X1TS
XU588 n3691 n7591 n3662 FE_OFN875_n3663
+ router_addr_calc_fft_read_calc_counter_N49 AOI22X1TS
XU574 n3684 n7566 FE_OFN885_n3662 FE_OFN869_n3663
+ router_addr_calc_fft_read_calc_counter_N56 AOI22X1TS
XU592 n3693 n7601 FE_OFN877_n3662 FE_OFN873_n3663
+ router_addr_calc_fft_read_calc_counter_N47 AOI22X1TS
XU402 n3585 FE_OFN1253_n7283 FE_OFN926_n3574 FE_OFN916_n3575
+ router_addr_calc_fir_read_calc_counter_N67 AOI22X1TS
XU507 n3644 n7457 FE_OFN962_n3618 FE_OFN959_n3619
+ router_addr_calc_fft_write_calc_counter_N52 AOI22X1TS
XU578 n3686 n7571 FE_OFN882_n3662 FE_OFN869_n3663
+ router_addr_calc_fft_read_calc_counter_N54 AOI22X1TS
XU499 n3640 n7442 FE_OFN965_n3618 FE_OFN958_n3619
+ router_addr_calc_fft_write_calc_counter_N56 AOI22X1TS
XU590 n3692 n7596 n3662 FE_OFN875_n3663
+ router_addr_calc_fft_read_calc_counter_N48 AOI22X1TS
XU515 n3648 n7477 FE_OFN963_n3618 FE_OFN960_n3619
+ router_addr_calc_fft_write_calc_counter_N48 AOI22X1TS
XU564 n3679 n7541 FE_OFN887_n3662 FE_OFN871_n3663
+ router_addr_calc_fft_read_calc_counter_N61 AOI22X1TS
XU594 n3694 router_addr_calc_fft_read_calc_count[0] FE_OFN878_n3662
+ FE_OFN873_n3663 n7957 AOI22X1TS
XU489 n3635 FE_OFN1270_router_addr_calc_fft_write_calc_count_15_
+ FE_OFN966_n3618 FE_OFN957_n3619 router_addr_calc_fft_write_calc_counter_N61
+ AOI22X1TS
XU517 n3649 n7482 FE_OFN970_n3618 n3619
+ router_addr_calc_fft_write_calc_counter_N47 AOI22X1TS
XU519 n3650 router_addr_calc_fft_write_calc_count[0] FE_OFN970_n3618 n3619
+ n7958 AOI22X1TS
XU509 n3645 n7462 FE_OFN962_n3618 FE_OFN959_n3619
+ router_addr_calc_fft_write_calc_counter_N51 AOI22X1TS
XU323 n3539 FE_OFN1248_router_addr_calc_fir_write_calc_count_23_
+ FE_OFN902_n3530 FE_OFN891_n3531 router_addr_calc_fir_write_calc_counter_N69
+ AOI22X1TS
XU1933 n6155 n8478 FE_OFN1495_acc_fft_data_in_23_ FE_OFN15_n4568
+ fifo_from_fft_fifo_cell2_sr_out[23] AO22XLTS
XU1019 n4115 n7430 n4113 n4117 OAI21XLTS
XU2681 n4822 n8877 n4824 fifo_from_fir_hang[1] n9466 OAI211XLTS
XU1935 n6157 n8478 FE_OFN1508_acc_fft_data_in_21_ FE_OFN16_n4568
+ fifo_from_fft_fifo_cell2_sr_out[21] AO22XLTS
XU1926 n6148 n8480 FE_OFN1462_acc_fft_data_in_30_ FE_OFN18_n4568
+ fifo_from_fft_fifo_cell2_sr_out[30] AO22XLTS
XU1936 n6158 n8478 FE_OFN1513_acc_fft_data_in_20_ FE_OFN15_n4568
+ fifo_from_fft_fifo_cell2_sr_out[20] AO22XLTS
XU1940 n6162 n8477 FE_OFN1534_acc_fft_data_in_16_ n4568
+ fifo_from_fft_fifo_cell2_sr_out[16] AO22XLTS
XU1937 n6159 n8477 FE_OFN1515_acc_fft_data_in_19_ FE_OFN10_n4568
+ fifo_from_fft_fifo_cell2_sr_out[19] AO22XLTS
XU1939 n6161 n8477 FE_OFN1532_acc_fft_data_in_17_ n4568
+ fifo_from_fft_fifo_cell2_sr_out[17] AO22XLTS
XU1938 n6160 n8477 FE_OFN1526_acc_fft_data_in_18_ FE_OFN10_n4568
+ fifo_from_fft_fifo_cell2_sr_out[18] AO22XLTS
XU1925 n6147 n8480 FE_OFN1456_acc_fft_data_in_31_ FE_OFN16_n4568
+ fifo_from_fft_fifo_cell2_sr_out[31] AO22XLTS
XU2565 n6685 n8143 FE_OFN1679_acc_fir_data_in_22_ FE_OFN356_n4754
+ fifo_from_fir_fifo_cell2_sr_out[22] AO22XLTS
XU1927 n6149 n8480 FE_OFN1467_acc_fft_data_in_29_ FE_OFN17_n4568
+ fifo_from_fft_fifo_cell2_sr_out[29] AO22XLTS
XU875 n3940 n7321 n3938 n3942 OAI21XLTS
XU2564 n6684 n8143 FE_OFN1677_acc_fir_data_in_23_ FE_OFN355_n4754
+ fifo_from_fir_fifo_cell2_sr_out[23] AO22XLTS
XU2566 n6686 n8143 FE_OFN1685_acc_fir_data_in_21_ FE_OFN356_n4754
+ fifo_from_fir_fifo_cell2_sr_out[21] AO22XLTS
XU2559 n6679 n8145 FE_OFN1648_acc_fir_data_in_28_ FE_OFN353_n4754
+ fifo_from_fir_fifo_cell2_sr_out[28] AO22XLTS
XU2050 n4636 n8844 n4638 fifo_from_fft_hang[1] n9469 OAI211XLTS
XU496 router_addr_calc_fft_write_calc_counter_N189 n9445 n3639 NAND2XLTS
XU571 router_addr_calc_fft_read_calc_counter_N189 n9436 n3683 NAND2XLTS
XU500 router_addr_calc_fft_write_calc_counter_N187 n9444 n3641 NAND2XLTS
XU408 n3588 n7293 FE_OFN925_n3574 FE_OFN915_n3575
+ router_addr_calc_fir_read_calc_counter_N64 AOI22X1TS
XU406 n3587 router_addr_calc_fir_read_calc_count[19] FE_OFN926_n3574
+ FE_OFN915_n3575 router_addr_calc_fir_read_calc_counter_N65 AOI22X1TS
XU410 n3589 FE_OFN1262_n7298 FE_OFN925_n3574 FE_OFN914_n3575
+ router_addr_calc_fir_read_calc_counter_N63 AOI22X1TS
XU337 n3546 router_addr_calc_fir_write_calc_count[16] FE_OFN908_n3530
+ FE_OFN896_n3531 router_addr_calc_fir_write_calc_counter_N62 AOI22X1TS
XU396 n3582 FE_OFN1243_n7273 FE_OFN927_n3574 FE_OFN917_n3575
+ router_addr_calc_fir_read_calc_counter_N70 AOI22X1TS
XU246 n3494 n7168 FE_OFN944_n3486 FE_OFN930_n3487
+ router_addr_calc_iir_write_calc_counter_N70 AOI22X1TS
XU333 n3544 n7171 FE_OFN908_n3530 FE_OFN895_n3531
+ router_addr_calc_fir_write_calc_counter_N64 AOI22X1TS
XU546 n3670 n7511 FE_OFN883_n3662 FE_OFN872_n3663
+ router_addr_calc_fft_read_calc_counter_N70 AOI22X1TS
XU471 n3626 n7387 FE_OFN970_n3618 FE_OFN951_n3619
+ router_addr_calc_fft_write_calc_counter_N70 AOI22X1TS
XU321 n3538 n7147 FE_OFN902_n3530 FE_OFN893_n3531
+ router_addr_calc_fir_write_calc_counter_N70 AOI22X1TS
XU575 router_addr_calc_fft_read_calc_counter_N187 n9436 n3685 NAND2XLTS
XU412 n3590 FE_OFN1265_n7303 FE_OFN924_n3574 FE_OFN913_n3575
+ router_addr_calc_fir_read_calc_counter_N62 AOI22X1TS
XU335 n3545 n7177 FE_OFN908_n3530 FE_OFN896_n3531
+ router_addr_calc_fir_write_calc_counter_N63 AOI22X1TS
XU331 n3543 FE_OFN1261_router_addr_calc_fir_write_calc_count_19_
+ FE_OFN905_n3530 FE_OFN895_n3531 router_addr_calc_fir_write_calc_counter_N65
+ AOI22X1TS
XU2569 n6689 n8142 FE_OFN1706_acc_fir_data_in_18_ FE_OFN355_n4754
+ fifo_from_fir_fifo_cell2_sr_out[18] AO22XLTS
XU2568 n6688 n8142 FE_OFN1697_acc_fir_data_in_19_ FE_OFN354_n4754
+ fifo_from_fir_fifo_cell2_sr_out[19] AO22XLTS
XU2570 n6690 n8142 FE_OFN1711_acc_fir_data_in_17_ FE_OFN354_n4754
+ fifo_from_fir_fifo_cell2_sr_out[17] AO22XLTS
XU2571 n6691 n8142 FE_OFN1718_acc_fir_data_in_16_ FE_OFN354_n4754
+ fifo_from_fir_fifo_cell2_sr_out[16] AO22XLTS
XU1016 n5555 fifo_to_fir_fifo_cell4_data_out_N35 n4114 n4115 OAI21XLTS
XU2572 n6692 n8141 FE_OFN1721_acc_fir_data_in_15_ FE_OFN357_n4754
+ fifo_from_fir_fifo_cell2_sr_out[15] AO22XLTS
XU2573 n6693 n8141 FE_OFN1729_acc_fir_data_in_14_ FE_OFN357_n4754
+ fifo_from_fir_fifo_cell2_sr_out[14] AO22XLTS
XU2574 n6694 n8141 FE_OFN1735_acc_fir_data_in_13_ FE_OFN357_n4754
+ fifo_from_fir_fifo_cell2_sr_out[13] AO22XLTS
XU2575 n6695 n8141 FE_OFN1740_acc_fir_data_in_12_ FE_OFN356_n4754
+ fifo_from_fir_fifo_cell2_sr_out[12] AO22XLTS
XU2576 n6696 n8140 FE_OFN1743_acc_fir_data_in_11_ FE_OFN358_n4754
+ fifo_from_fir_fifo_cell2_sr_out[11] AO22XLTS
XU2577 n6697 n8140 FE_OFN1748_acc_fir_data_in_10_ FE_OFN358_n4754
+ fifo_from_fir_fifo_cell2_sr_out[10] AO22XLTS
XU2578 n6698 n8140 FE_OFN1755_acc_fir_data_in_9_ FE_OFN358_n4754
+ fifo_from_fir_fifo_cell2_sr_out[9] AO22XLTS
XU2579 n6699 n8140 FE_OFN1760_acc_fir_data_in_8_ FE_OFN358_n4754
+ fifo_from_fir_fifo_cell2_sr_out[8] AO22XLTS
XU2580 n6700 n8139 FE_OFN1767_acc_fir_data_in_7_ FE_OFN349_n4754
+ fifo_from_fir_fifo_cell2_sr_out[7] AO22XLTS
XU2581 n6701 n8139 FE_OFN1776_acc_fir_data_in_6_ FE_OFN349_n4754
+ fifo_from_fir_fifo_cell2_sr_out[6] AO22XLTS
XU2582 n6702 n8139 FE_OFN1779_acc_fir_data_in_5_ FE_OFN351_n4754
+ fifo_from_fir_fifo_cell2_sr_out[5] AO22XLTS
XU2583 n6703 n8139 FE_OFN1789_acc_fir_data_in_4_ FE_OFN351_n4754
+ fifo_from_fir_fifo_cell2_sr_out[4] AO22XLTS
XU2584 n6704 n8138 FE_OFN1792_acc_fir_data_in_3_ FE_OFN352_n4754
+ fifo_from_fir_fifo_cell2_sr_out[3] AO22XLTS
XU2585 n6705 n8138 FE_OFN1799_acc_fir_data_in_2_ FE_OFN352_n4754
+ fifo_from_fir_fifo_cell2_sr_out[2] AO22XLTS
XU2586 n6706 n8138 FE_OFN1804_acc_fir_data_in_1_ FE_OFN351_n4754
+ fifo_from_fir_fifo_cell2_sr_out[1] AO22XLTS
XU2587 n6707 n8138 FE_OFN1814_acc_fir_data_in_0_ FE_OFN352_n4754
+ fifo_from_fir_fifo_cell2_sr_out[0] AO22XLTS
XU1062 n4033 n4117 n4034 n4169 NAND3XLTS
XU1018 n5556 fifo_to_fir_fifo_cell4_controller_valid_read n4115 FE_OFN804_n7619
+ AOI21X1TS
XU1928 n6150 n8480 FE_OFN1471_acc_fft_data_in_28_ FE_OFN17_n4568
+ fifo_from_fft_fifo_cell2_sr_out[28] AO22XLTS
XU874 n5504 fifo_to_fft_fifo_cell4_controller_valid_read n3940 FE_OFN819_n7619
+ AOI21X1TS
XU872 n5503 fifo_to_fft_fifo_cell4_data_out_N35 n3939 n3940 OAI21XLTS
XU918 n3858 n3942 n3859 n3994 NAND3XLTS
XU2556 n6676 n8145 FE_OFN1631_acc_fir_data_in_31_ FE_OFN353_n4754
+ fifo_from_fir_fifo_cell2_sr_out[31] AO22XLTS
XU2557 n6677 n8145 FE_OFN1634_acc_fir_data_in_30_ FE_OFN353_n4754
+ fifo_from_fir_fifo_cell2_sr_out[30] AO22XLTS
XU2558 n6678 n8145 FE_OFN1644_acc_fir_data_in_29_ FE_OFN353_n4754
+ fifo_from_fir_fifo_cell2_sr_out[29] AO22XLTS
XU544 n3669 n7506 FE_OFN880_n3662 n3663
+ router_addr_calc_fft_read_calc_counter_N71 AOI22X1TS
XU394 n3581 FE_OFN1242_n7268 FE_OFN921_n3574 n3575
+ router_addr_calc_fir_read_calc_counter_N71 AOI22X1TS
XU416 n3592 FE_OFN1277_n7308 FE_OFN925_n3574 FE_OFN914_n3575
+ router_addr_calc_fir_read_calc_counter_N60 AOI22X1TS
XU343 n3549 n7195 FE_OFN907_n3530 FE_OFN892_n3531
+ router_addr_calc_fir_write_calc_counter_N59 AOI22X1TS
XU365 n3560 n7239 FE_OFN901_n3530 FE_OFN888_n3531
+ router_addr_calc_fir_write_calc_counter_N48 AOI22X1TS
XU244 n3493 n7174 FE_OFN943_n3486 FE_OFN930_n3487
+ router_addr_calc_iir_write_calc_counter_N71 AOI22X1TS
XU424 n3596 FE_OFN1279_n7328 FE_OFN923_n3574 FE_OFN912_n3575
+ router_addr_calc_fir_read_calc_counter_N56 AOI22X1TS
XU367 n3561 n7244 FE_OFN903_n3530 n3531
+ router_addr_calc_fir_write_calc_counter_N47 AOI22X1TS
XU341 n3548 n7189 FE_OFN907_n3530 FE_OFN892_n3531
+ router_addr_calc_fir_write_calc_counter_N60 AOI22X1TS
XU339 n3547 n7183 FE_OFN908_n3530 FE_OFN896_n3531
+ router_addr_calc_fir_write_calc_counter_N61 AOI22X1TS
XU353 n3554 n7214 FE_OFN906_n3530 FE_OFN890_n3531
+ router_addr_calc_fir_write_calc_counter_N54 AOI22X1TS
XU663 n5375 n3746 CLKINVX1TS
XU430 n3599 n7338 FE_OFN922_n3574 FE_OFN911_n3575
+ router_addr_calc_fir_read_calc_counter_N53 AOI22X1TS
XU665 n5376 n3747 CLKINVX1TS
XU667 n5377 n3748 CLKINVX1TS
XU669 n5378 n3749 CLKINVX1TS
XU645 n5366 n3737 CLKINVX1TS
XU428 n3598 FE_OFN1278_n7333 FE_OFN922_n3574 FE_OFN911_n3575
+ router_addr_calc_fir_read_calc_counter_N54 AOI22X1TS
XU671 n5379 n3750 CLKINVX1TS
XU349 n3552 n7209 FE_OFN904_n3530 FE_OFN889_n3531
+ router_addr_calc_fir_write_calc_counter_N56 AOI22X1TS
XU673 n5380 n3751 CLKINVX1TS
XU675 n5381 n3752 CLKINVX1TS
XU432 n3600 n7343 FE_OFN920_n3574 FE_OFN911_n3575
+ router_addr_calc_fir_read_calc_counter_N52 AOI22X1TS
XU677 n5382 n3753 CLKINVX1TS
XU643 n5365 n3736 CLKINVX1TS
XU359 n3557 router_addr_calc_fir_write_calc_count[5] FE_OFN898_n3530
+ FE_OFN897_n3531 router_addr_calc_fir_write_calc_counter_N51 AOI22X1TS
XU641 n5364 n3735 CLKINVX1TS
XU369 n3562 router_addr_calc_fir_write_calc_count[0] FE_OFN898_n3530
+ FE_OFN897_n3531 n7956 AOI22X1TS
XU357 n3556 n7224 FE_OFN906_n3530 FE_OFN890_n3531
+ router_addr_calc_fir_write_calc_counter_N52 AOI22X1TS
XU469 n3625 n7382 FE_OFN971_n3618 FE_OFN954_n3619
+ router_addr_calc_fft_write_calc_counter_N71 AOI22X1TS
XU434 n3601 FE_OFN1276_router_addr_calc_fir_read_calc_count_5_ FE_OFN920_n3574
+ FE_OFN910_n3575 router_addr_calc_fir_read_calc_counter_N51 AOI22X1TS
XU639 n5363 n3734 CLKINVX1TS
XU436 n3602 n7348 FE_OFN919_n3574 FE_OFN909_n3575
+ router_addr_calc_fir_read_calc_counter_N50 AOI22X1TS
XU361 n3558 n7229 FE_OFN899_n3530 FE_OFN888_n3531
+ router_addr_calc_fir_write_calc_counter_N50 AOI22X1TS
XU420 n3594 n7318 FE_OFN923_n3574 FE_OFN912_n3575
+ router_addr_calc_fir_read_calc_counter_N58 AOI22X1TS
XU438 n3603 FE_OFN1275_n7353 FE_OFN919_n3574 FE_OFN909_n3575
+ router_addr_calc_fir_read_calc_counter_N49 AOI22X1TS
XU637 n5362 n3733 CLKINVX1TS
XU440 n3604 FE_OFN1274_n7358 n3574 FE_OFN909_n3575
+ router_addr_calc_fir_read_calc_counter_N48 AOI22X1TS
XU442 n3605 n7363 FE_OFN921_n3574 n3575
+ router_addr_calc_fir_read_calc_counter_N47 AOI22X1TS
XU635 n5361 n3732 CLKINVX1TS
XU444 n3606 FE_OFN1446_router_addr_calc_fir_read_calc_count_0_ FE_OFN922_n3574
+ FE_OFN910_n3575 n7955 AOI22X1TS
XU414 n3591 FE_OFN1271_router_addr_calc_fir_read_calc_count_15_ FE_OFN924_n3574
+ FE_OFN913_n3575 router_addr_calc_fir_read_calc_counter_N61 AOI22X1TS
XU633 n5360 n3731 CLKINVX1TS
XU319 n3537 n7141 FE_OFN900_n3530 FE_OFN893_n3531
+ router_addr_calc_fir_write_calc_counter_N71 AOI22X1TS
XU631 n5359 n3730 CLKINVX1TS
XU355 n3555 n7219 FE_OFN906_n3530 FE_OFN890_n3531
+ router_addr_calc_fir_write_calc_counter_N53 AOI22X1TS
XU345 n3550 n7201 FE_OFN907_n3530 FE_OFN892_n3531
+ router_addr_calc_fir_write_calc_counter_N58 AOI22X1TS
XU363 n3559 n7234 FE_OFN901_n3530 n3531
+ router_addr_calc_fir_write_calc_counter_N49 AOI22X1TS
XU418 n3593 n7313 FE_OFN924_n3574 FE_OFN913_n3575
+ router_addr_calc_fir_read_calc_counter_N59 AOI22X1TS
XU2562 n6682 n8144 FE_OFN1661_acc_fir_data_in_25_ n4754
+ fifo_from_fir_fifo_cell2_sr_out[25] AO22XLTS
XU2561 n6681 n8144 FE_OFN1659_acc_fir_data_in_26_ FE_OFN350_n4754
+ fifo_from_fir_fifo_cell2_sr_out[26] AO22XLTS
XU2560 n6680 n8144 FE_OFN1654_acc_fir_data_in_27_ FE_OFN350_n4754
+ fifo_from_fir_fifo_cell2_sr_out[27] AO22XLTS
XU2563 n6683 n8144 FE_OFN1666_acc_fir_data_in_24_ FE_OFN350_n4754
+ fifo_from_fir_fifo_cell2_sr_out[24] AO22XLTS
XU1929 n6151 n8479 FE_OFN1475_acc_fft_data_in_27_ FE_OFN20_n4568
+ fifo_from_fft_fifo_cell2_sr_out[27] AO22XLTS
XU1930 n6152 n8479 FE_OFN1481_acc_fft_data_in_26_ FE_OFN20_n4568
+ fifo_from_fft_fifo_cell2_sr_out[26] AO22XLTS
XU1931 n6153 n8479 FE_OFN1486_acc_fft_data_in_25_ FE_OFN21_n4568
+ fifo_from_fft_fifo_cell2_sr_out[25] AO22XLTS
XU1932 n6154 n8479 FE_OFN1492_acc_fft_data_in_24_ FE_OFN21_n4568
+ fifo_from_fft_fifo_cell2_sr_out[24] AO22XLTS
XU1949 n6171 n8474 FE_OFN1580_acc_fft_data_in_7_ FE_OFN19_n4568
+ fifo_from_fft_fifo_cell2_sr_out[7] AO22XLTS
XU1950 n6172 n8474 FE_OFN1589_acc_fft_data_in_6_ FE_OFN19_n4568
+ fifo_from_fft_fifo_cell2_sr_out[6] AO22XLTS
XU1956 n6178 n8473 FE_OFN1627_acc_fft_data_in_0_ FE_OFN18_n4568
+ fifo_from_fft_fifo_cell2_sr_out[0] AO22XLTS
XU1942 n6164 n8476 FE_OFN1547_acc_fft_data_in_14_ FE_OFN11_n4568
+ fifo_from_fft_fifo_cell2_sr_out[14] AO22XLTS
XU1946 n6168 n8475 FE_OFN1567_acc_fft_data_in_10_ FE_OFN13_n4568
+ fifo_from_fft_fifo_cell2_sr_out[10] AO22XLTS
XU1941 n6163 n8476 FE_OFN1540_acc_fft_data_in_15_ FE_OFN11_n4568
+ fifo_from_fft_fifo_cell2_sr_out[15] AO22XLTS
XU1947 n6169 n8475 FE_OFN1572_acc_fft_data_in_9_ FE_OFN14_n4568
+ fifo_from_fft_fifo_cell2_sr_out[9] AO22XLTS
XU1952 n6174 n8474 FE_OFN1602_acc_fft_data_in_4_ FE_OFN19_n4568
+ fifo_from_fft_fifo_cell2_sr_out[4] AO22XLTS
XU1944 n6166 n8476 FE_OFN1557_acc_fft_data_in_12_ FE_OFN10_n4568
+ fifo_from_fft_fifo_cell2_sr_out[12] AO22XLTS
XU1943 n6165 n8476 FE_OFN1552_acc_fft_data_in_13_ FE_OFN11_n4568
+ fifo_from_fft_fifo_cell2_sr_out[13] AO22XLTS
XU1954 n6176 n8473 FE_OFN1613_acc_fft_data_in_2_ FE_OFN21_n4568
+ fifo_from_fft_fifo_cell2_sr_out[2] AO22XLTS
XU1955 n6177 n8473 FE_OFN1618_acc_fft_data_in_1_ FE_OFN21_n4568
+ fifo_from_fft_fifo_cell2_sr_out[1] AO22XLTS
XU1945 n6167 n8475 FE_OFN1562_acc_fft_data_in_11_ FE_OFN14_n4568
+ fifo_from_fft_fifo_cell2_sr_out[11] AO22XLTS
XU1063 n4168 n8790 n4170 fifo_to_fir_hang[3] n9474 OAI211XLTS
XU919 n3993 n8811 n3995 fifo_to_fft_hang[3] n9478 OAI211XLTS
XU1953 n6175 n8473 FE_OFN1606_acc_fft_data_in_3_ FE_OFN20_n4568
+ fifo_from_fft_fifo_cell2_sr_out[3] AO22XLTS
XU1948 n6170 n8475 FE_OFN1576_acc_fft_data_in_8_ FE_OFN14_n4568
+ fifo_from_fft_fifo_cell2_sr_out[8] AO22XLTS
XU1951 n6173 n8474 FE_OFN1595_acc_fft_data_in_5_ FE_OFN19_n4568
+ fifo_from_fft_fifo_cell2_sr_out[5] AO22XLTS
XU615 n5351 n3719 CLKINVX1TS
XU623 n5355 n3726 CLKINVX1TS
XU625 n5356 n3727 CLKINVX1TS
XU617 n5352 n3723 CLKINVX1TS
XU627 n5357 n3728 CLKINVX1TS
XU629 n5358 n3729 CLKINVX1TS
XU621 n5354 n3725 CLKINVX1TS
XU619 n5353 n3724 CLKINVX1TS
XU647 n5367 n3738 CLKINVX1TS
XU649 n5368 n3739 CLKINVX1TS
XU651 n5369 n3740 CLKINVX1TS
XU653 n5370 n3741 CLKINVX1TS
XU655 n5371 n3742 CLKINVX1TS
XU467 n3624 n7377 FE_OFN971_n3618 FE_OFN954_n3619
+ router_addr_calc_fft_write_calc_counter_N72 AOI22X1TS
XU657 n5372 n3743 CLKINVX1TS
XU659 n5373 n3744 CLKINVX1TS
XU661 n5374 n3745 CLKINVX1TS
XU346 router_addr_calc_fir_write_calc_counter_N189 n9417 n3551 NAND2XLTS
XU317 n3536 n7135 FE_OFN900_n3530 FE_OFN894_n3531
+ router_addr_calc_fir_write_calc_counter_N72 AOI22X1TS
XU443 router_addr_calc_fir_read_calc_counter_N178 n9407 n3606 NAND2XLTS
XU421 router_addr_calc_fir_read_calc_counter_N189 n9410 n3595 NAND2XLTS
XU392 n3580 n7263 FE_OFN928_n3574 FE_OFN917_n3575
+ router_addr_calc_fir_read_calc_counter_N72 AOI22X1TS
XU542 n3668 n7501 FE_OFN880_n3662 FE_OFN868_n3663
+ router_addr_calc_fft_read_calc_counter_N72 AOI22X1TS
XU425 router_addr_calc_fir_read_calc_counter_N187 n9413 n3597 NAND2XLTS
XU350 router_addr_calc_fir_write_calc_counter_N187 n9417 n3553 NAND2XLTS
XU242 n3492 n7180 FE_OFN943_n3486 FE_OFN930_n3487
+ router_addr_calc_iir_write_calc_counter_N72 AOI22X1TS
XU2554 n4749 n7589 n4752 FE_OFN653_n4747 OAI21XLTS
XU465 n3623 router_addr_calc_fft_write_calc_count[27] FE_OFN972_n3618
+ FE_OFN954_n3619 router_addr_calc_fft_write_calc_counter_N73 AOI22X1TS
XU240 n3491 FE_OFN1439_router_addr_calc_iir_write_calc_count_27_
+ FE_OFN943_n3486 FE_OFN933_n3487 router_addr_calc_iir_write_calc_counter_N73
+ AOI22X1TS
XU390 n3579 FE_OFN1239_router_addr_calc_fir_read_calc_count_27_ FE_OFN928_n3574
+ FE_OFN918_n3575 router_addr_calc_fir_read_calc_counter_N73 AOI22X1TS
XU315 n3535 router_addr_calc_fir_write_calc_count[27] FE_OFN900_n3530
+ FE_OFN894_n3531 router_addr_calc_fir_write_calc_counter_N73 AOI22X1TS
XU540 n3667 FE_OFN1237_router_addr_calc_fft_read_calc_count_27_ FE_OFN879_n3662
+ FE_OFN868_n3663 router_addr_calc_fft_read_calc_counter_N73 AOI22X1TS
XU2678 n4649 FE_OFN654_n4747 n4650 n4820 NAND3XLTS
XU1923 n4563 n7514 n4566 FE_OFN313_n4561 OAI21X1TS
XU2552 n6674 fifo_from_fir_fifo_cell3_controller_valid_read n4749
+ FE_OFN828_n7619 AOI21X1TS
XU2553 n6675 fifo_from_fir_fifo_cell3_data_out_N35 n4751 n4749 OAI21XLTS
XU463 n3622 n7372 FE_OFN972_n3618 FE_OFN952_n3619
+ router_addr_calc_fft_write_calc_counter_N74 AOI22X1TS
XU388 n3578 n7258 FE_OFN928_n3574 FE_OFN917_n3575
+ router_addr_calc_fir_read_calc_counter_N74 AOI22X1TS
XU538 n3666 n7496 FE_OFN879_n3662 FE_OFN870_n3663
+ router_addr_calc_fft_read_calc_counter_N74 AOI22X1TS
XU238 n3490 n7186 FE_OFN941_n3486 FE_OFN933_n3487
+ router_addr_calc_iir_write_calc_counter_N74 AOI22X1TS
XU313 n3534 n7129 FE_OFN900_n3530 FE_OFN893_n3531
+ router_addr_calc_fir_write_calc_counter_N74 AOI22X1TS
XU2521 n6644 FE_OFN657_n4747 FE_OFN1643_acc_fir_data_in_29_ FE_OFN367_n4748
+ fifo_from_fir_fifo_cell3_sr_out[29] AO22XLTS
XU2522 n6645 FE_OFN657_n4747 FE_OFN1648_acc_fir_data_in_28_ FE_OFN367_n4748
+ fifo_from_fir_fifo_cell3_sr_out[28] AO22XLTS
XU2519 n6642 FE_OFN657_n4747 FE_OFN1630_acc_fir_data_in_31_ FE_OFN367_n4748
+ fifo_from_fir_fifo_cell3_sr_out[31] AO22XLTS
XU2520 n6643 FE_OFN655_n4747 FE_OFN1635_acc_fir_data_in_30_ FE_OFN367_n4748
+ fifo_from_fir_fifo_cell3_sr_out[30] AO22XLTS
XU2536 n6659 FE_OFN663_n4747 FE_OFN1730_acc_fir_data_in_14_ FE_OFN368_n4748
+ fifo_from_fir_fifo_cell3_sr_out[14] AO22XLTS
XU2537 n6660 FE_OFN661_n4747 FE_OFN1733_acc_fir_data_in_13_ FE_OFN363_n4748
+ fifo_from_fir_fifo_cell3_sr_out[13] AO22XLTS
XU2538 n6661 FE_OFN663_n4747 FE_OFN1739_acc_fir_data_in_12_ FE_OFN368_n4748
+ fifo_from_fir_fifo_cell3_sr_out[12] AO22XLTS
XU1921 n6145 fifo_from_fft_fifo_cell3_controller_valid_read n4563
+ FE_OFN818_n7619 AOI21X1TS
XU2047 n4463 n4561 n4464 n4634 NAND3XLTS
XU2535 n6658 FE_OFN663_n4747 FE_OFN1723_acc_fir_data_in_15_ FE_OFN368_n4748
+ fifo_from_fir_fifo_cell3_sr_out[15] AO22XLTS
XU2679 n4819 n8876 n4821 fifo_from_fir_hang[2] n9466 OAI211XLTS
XU1922 n6146 fifo_from_fft_fifo_cell3_data_out_N35 n4565 n4563 OAI21XLTS
XU536 n3665 FE_OFN1234_n7492 FE_OFN878_n3662 FE_OFN870_n3663
+ router_addr_calc_fft_read_calc_counter_N75 AOI22X1TS
XU386 n3577 FE_OFN1235_n7254 FE_OFN929_n3574 FE_OFN918_n3575
+ router_addr_calc_fir_read_calc_counter_N75 AOI22X1TS
XU311 n3533 n7124 FE_OFN899_n3530 FE_OFN894_n3531
+ router_addr_calc_fir_write_calc_counter_N75 AOI22X1TS
XU461 n3621 router_addr_calc_fft_write_calc_count[29] FE_OFN972_n3618
+ FE_OFN952_n3619 router_addr_calc_fft_write_calc_counter_N75 AOI22X1TS
XU236 n3489 n7192 FE_OFN941_n3486 FE_OFN933_n3487
+ router_addr_calc_iir_write_calc_counter_N75 AOI22X1TS
XU1896 n6121 FE_OFN316_n4561 FE_OFN1494_acc_fft_data_in_23_ FE_OFN23_n4562
+ fifo_from_fft_fifo_cell3_sr_out[23] AO22XLTS
XU1011 n5552 fifo_to_fir_fifo_cell5_data_out_N35 n4109 n4110 OAI21XLTS
XU1898 n6123 FE_OFN319_n4561 FE_OFN1508_acc_fft_data_in_21_ FE_OFN27_n4562
+ fifo_from_fft_fifo_cell3_sr_out[21] AO22XLTS
XU867 n5500 fifo_to_fft_fifo_cell5_data_out_N35 n3934 n3935 OAI21XLTS
XU2048 n4633 n8843 n4635 fifo_from_fft_hang[2] n9470 OAI211XLTS
XU1888 n6113 FE_OFN317_n4561 FE_OFN1456_acc_fft_data_in_31_ FE_OFN27_n4562
+ fifo_from_fft_fifo_cell3_sr_out[31] AO22XLTS
XU1897 n6122 FE_OFN319_n4561 FE_OFN1503_acc_fft_data_in_22_ FE_OFN29_n4562
+ fifo_from_fft_fifo_cell3_sr_out[22] AO22XLTS
XU2550 n6673 FE_OFN656_n4747 FE_OFN1814_acc_fir_data_in_0_ FE_OFN359_n4748
+ fifo_from_fir_fifo_cell3_sr_out[0] AO22XLTS
XU1889 n6114 FE_OFN321_n4561 FE_OFN1462_acc_fft_data_in_30_ FE_OFN28_n4562
+ fifo_from_fft_fifo_cell3_sr_out[30] AO22XLTS
XU869 n5501 fifo_to_fft_fifo_cell5_controller_valid_read n3935 FE_OFN826_n7619
+ AOI21X1TS
XU2549 n6672 FE_OFN656_n4747 FE_OFN1804_acc_fir_data_in_1_ FE_OFN359_n4748
+ fifo_from_fir_fifo_cell3_sr_out[1] AO22XLTS
XU1899 n6124 FE_OFN322_n4561 FE_OFN1514_acc_fft_data_in_20_ FE_OFN29_n4562
+ fifo_from_fft_fifo_cell3_sr_out[20] AO22XLTS
XU2527 n6650 FE_OFN659_n4747 FE_OFN1673_acc_fir_data_in_23_ FE_OFN360_n4748
+ fifo_from_fir_fifo_cell3_sr_out[23] AO22XLTS
XU2548 n6671 FE_OFN656_n4747 FE_OFN1797_acc_fir_data_in_2_ FE_OFN359_n4748
+ fifo_from_fir_fifo_cell3_sr_out[2] AO22XLTS
XU2547 n6670 FE_OFN658_n4747 FE_OFN1792_acc_fir_data_in_3_ n4748
+ fifo_from_fir_fifo_cell3_sr_out[3] AO22XLTS
XU2546 n6669 FE_OFN654_n4747 FE_OFN1784_acc_fir_data_in_4_ FE_OFN362_n4748
+ fifo_from_fir_fifo_cell3_sr_out[4] AO22XLTS
XU2545 n6668 n4747 FE_OFN1780_acc_fir_data_in_5_ FE_OFN364_n4748
+ fifo_from_fir_fifo_cell3_sr_out[5] AO22XLTS
XU1890 n6115 FE_OFN318_n4561 FE_OFN1467_acc_fft_data_in_29_ FE_OFN26_n4562
+ fifo_from_fft_fifo_cell3_sr_out[29] AO22XLTS
XU2544 n6667 FE_OFN657_n4747 FE_OFN1769_acc_fir_data_in_6_ FE_OFN364_n4748
+ fifo_from_fir_fifo_cell3_sr_out[6] AO22XLTS
XU2543 n6666 FE_OFN654_n4747 FE_OFN1768_acc_fir_data_in_7_ FE_OFN362_n4748
+ fifo_from_fir_fifo_cell3_sr_out[7] AO22XLTS
XU2542 n6665 FE_OFN662_n4747 FE_OFN1761_acc_fir_data_in_8_ FE_OFN366_n4748
+ fifo_from_fir_fifo_cell3_sr_out[8] AO22XLTS
XU2541 n6664 FE_OFN662_n4747 FE_OFN1754_acc_fir_data_in_9_ FE_OFN366_n4748
+ fifo_from_fir_fifo_cell3_sr_out[9] AO22XLTS
XU1891 n6116 FE_OFN318_n4561 FE_OFN1471_acc_fft_data_in_28_ FE_OFN27_n4562
+ fifo_from_fft_fifo_cell3_sr_out[28] AO22XLTS
XU2540 n6663 FE_OFN662_n4747 FE_OFN1747_acc_fir_data_in_10_ FE_OFN366_n4748
+ fifo_from_fir_fifo_cell3_sr_out[10] AO22XLTS
XU2539 n6662 FE_OFN661_n4747 FE_OFN1745_acc_fir_data_in_11_ FE_OFN363_n4748
+ fifo_from_fir_fifo_cell3_sr_out[11] AO22XLTS
XU916 n3860 n7315 n3861 n3991 NAND3XLTS
XU2530 n6653 FE_OFN659_n4747 FE_OFN1694_acc_fir_data_in_20_ FE_OFN360_n4748
+ fifo_from_fir_fifo_cell3_sr_out[20] AO22XLTS
XU1060 n4035 n7424 n4036 n4166 NAND3XLTS
XU2523 n6646 FE_OFN655_n4747 FE_OFN1653_acc_fir_data_in_27_ FE_OFN365_n4748
+ fifo_from_fir_fifo_cell3_sr_out[27] AO22XLTS
XU2524 n6647 FE_OFN655_n4747 FE_OFN1818_acc_fir_data_in_26_ FE_OFN365_n4748
+ fifo_from_fir_fifo_cell3_sr_out[26] AO22XLTS
XU2533 n6656 FE_OFN660_n4747 FE_OFN1708_acc_fir_data_in_17_ FE_OFN361_n4748
+ fifo_from_fir_fifo_cell3_sr_out[17] AO22XLTS
XU2525 n6648 FE_OFN652_n4747 FE_OFN1661_acc_fir_data_in_25_ FE_OFN365_n4748
+ fifo_from_fir_fifo_cell3_sr_out[25] AO22XLTS
XU2529 n6652 FE_OFN660_n4747 FE_OFN1683_acc_fir_data_in_21_ FE_OFN360_n4748
+ fifo_from_fir_fifo_cell3_sr_out[21] AO22XLTS
XU2531 n6654 FE_OFN659_n4747 FE_OFN1701_acc_fir_data_in_19_ n4748
+ fifo_from_fir_fifo_cell3_sr_out[19] AO22XLTS
XU2534 n6657 FE_OFN660_n4747 FE_OFN1716_acc_fir_data_in_16_ FE_OFN361_n4748
+ fifo_from_fir_fifo_cell3_sr_out[16] AO22XLTS
XU2526 n6649 FE_OFN652_n4747 FE_OFN1666_acc_fir_data_in_24_ FE_OFN365_n4748
+ fifo_from_fir_fifo_cell3_sr_out[24] AO22XLTS
XU2528 n6651 FE_OFN663_n4747 FE_OFN1682_acc_fir_data_in_22_ FE_OFN368_n4748
+ fifo_from_fir_fifo_cell3_sr_out[22] AO22XLTS
XU2532 n6655 FE_OFN661_n4747 FE_OFN1703_acc_fir_data_in_18_ FE_OFN363_n4748
+ fifo_from_fir_fifo_cell3_sr_out[18] AO22XLTS
XU309 n3532 FE_OFN1231_router_addr_calc_fir_write_calc_count_30_ n3530
+ FE_OFN897_n3531 router_addr_calc_fir_write_calc_counter_N76 AOI22X1TS
XU234 n3488 router_addr_calc_iir_write_calc_count[30] FE_OFN941_n3486
+ FE_OFN933_n3487 router_addr_calc_iir_write_calc_counter_N76 AOI22X1TS
XU384 n3576 router_addr_calc_fir_read_calc_count[30] FE_OFN929_n3574
+ FE_OFN918_n3575 router_addr_calc_fir_read_calc_counter_N76 AOI22X1TS
XU534 n3664 router_addr_calc_fft_read_calc_count[30] FE_OFN879_n3662
+ FE_OFN873_n3663 router_addr_calc_fft_read_calc_counter_N76 AOI22X1TS
XU459 n3620 FE_OFN1232_n7368 FE_OFN963_n3618 FE_OFN960_n3619
+ router_addr_calc_fft_write_calc_counter_N76 AOI22X1TS
XU1914 n6139 FE_OFN317_n4561 FE_OFN1591_acc_fft_data_in_5_ FE_OFN26_n4562
+ fifo_from_fft_fifo_cell3_sr_out[5] AO22XLTS
XU1908 n6133 FE_OFN322_n4561 FE_OFN1563_acc_fft_data_in_11_ FE_OFN31_n4562
+ fifo_from_fft_fifo_cell3_sr_out[11] AO22XLTS
XU1915 n6140 FE_OFN314_n4561 FE_OFN1600_acc_fft_data_in_4_ FE_OFN22_n4562
+ fifo_from_fft_fifo_cell3_sr_out[4] AO22XLTS
XU1906 n6131 FE_OFN323_n4561 FE_OFN1549_acc_fft_data_in_13_ FE_OFN30_n4562
+ fifo_from_fft_fifo_cell3_sr_out[13] AO22XLTS
XU1901 n6126 FE_OFN316_n4561 FE_OFN1520_acc_fft_data_in_18_ FE_OFN23_n4562
+ fifo_from_fft_fifo_cell3_sr_out[18] AO22XLTS
XU1893 n6118 FE_OFN321_n4561 FE_OFN1479_acc_fft_data_in_26_ FE_OFN28_n4562
+ fifo_from_fft_fifo_cell3_sr_out[26] AO22XLTS
XU1910 n6135 FE_OFN322_n4561 FE_OFN1570_acc_fft_data_in_9_ FE_OFN31_n4562
+ fifo_from_fft_fifo_cell3_sr_out[9] AO22XLTS
XU1905 n6130 FE_OFN324_n4561 FE_OFN1544_acc_fft_data_in_14_ FE_OFN32_n4562
+ fifo_from_fft_fifo_cell3_sr_out[14] AO22XLTS
XU1061 n4165 n8790 n4167 fifo_to_fir_hang[4] n9472 OAI211XLTS
XU1904 n6129 FE_OFN323_n4561 FE_OFN1542_acc_fft_data_in_15_ FE_OFN30_n4562
+ fifo_from_fft_fifo_cell3_sr_out[15] AO22XLTS
XU1900 n6125 FE_OFN313_n4561 FE_OFN1517_acc_fft_data_in_19_ n4562
+ fifo_from_fft_fifo_cell3_sr_out[19] AO22XLTS
XU1909 n6134 FE_OFN319_n4561 FE_OFN1567_acc_fft_data_in_10_ FE_OFN29_n4562
+ fifo_from_fft_fifo_cell3_sr_out[10] AO22XLTS
XU1911 n6136 FE_OFN323_n4561 FE_OFN1576_acc_fft_data_in_8_ FE_OFN31_n4562
+ fifo_from_fft_fifo_cell3_sr_out[8] AO22XLTS
XU1916 n6141 FE_OFN321_n4561 FE_OFN1603_acc_fft_data_in_3_ FE_OFN28_n4562
+ fifo_from_fft_fifo_cell3_sr_out[3] AO22XLTS
XU1913 n6138 FE_OFN316_n4561 FE_OFN1586_acc_fft_data_in_6_ FE_OFN23_n4562
+ fifo_from_fft_fifo_cell3_sr_out[6] AO22XLTS
XU1895 n6120 FE_OFN320_n4561 FE_OFN1489_acc_fft_data_in_24_ FE_OFN25_n4562
+ fifo_from_fft_fifo_cell3_sr_out[24] AO22XLTS
XU1917 n6142 FE_OFN320_n4561 FE_OFN1609_acc_fft_data_in_2_ FE_OFN25_n4562
+ fifo_from_fft_fifo_cell3_sr_out[2] AO22XLTS
XU1892 n6117 FE_OFN315_n4561 FE_OFN1474_acc_fft_data_in_27_ FE_OFN24_n4562
+ fifo_from_fft_fifo_cell3_sr_out[27] AO22XLTS
XU1907 n6132 FE_OFN324_n4561 FE_OFN1555_acc_fft_data_in_12_ FE_OFN32_n4562
+ fifo_from_fft_fifo_cell3_sr_out[12] AO22XLTS
XU1918 n6143 FE_OFN315_n4561 FE_OFN1616_acc_fft_data_in_1_ FE_OFN24_n4562
+ fifo_from_fft_fifo_cell3_sr_out[1] AO22XLTS
XU1912 n6137 FE_OFN315_n4561 FE_OFN1583_acc_fft_data_in_7_ FE_OFN22_n4562
+ fifo_from_fft_fifo_cell3_sr_out[7] AO22XLTS
XU917 n3990 n8811 n3992 fifo_to_fft_hang[4] n9476 OAI211XLTS
XU1903 n6128 FE_OFN324_n4561 FE_OFN1533_acc_fft_data_in_16_ FE_OFN32_n4562
+ fifo_from_fft_fifo_cell3_sr_out[16] AO22XLTS
XU1919 n6144 FE_OFN321_n4561 FE_OFN1627_acc_fft_data_in_0_ FE_OFN28_n4562
+ fifo_from_fft_fifo_cell3_sr_out[0] AO22XLTS
XU1894 n6119 FE_OFN320_n4561 FE_OFN1486_acc_fft_data_in_25_ FE_OFN25_n4562
+ fifo_from_fft_fifo_cell3_sr_out[25] AO22XLTS
XU1902 n6127 FE_OFN324_n4561 FE_OFN1529_acc_fft_data_in_17_ FE_OFN32_n4562
+ fifo_from_fft_fifo_cell3_sr_out[17] AO22XLTS
XU382 n3573 n7249 FE_OFN929_n3574 FE_OFN918_n3575
+ router_addr_calc_fir_read_calc_counter_N77 AOI22X1TS
XU457 n3617 router_addr_calc_fft_write_calc_count[31] FE_OFN972_n3618
+ FE_OFN952_n3619 router_addr_calc_fft_write_calc_counter_N77 AOI22X1TS
XU307 n3529 n7118 FE_OFN898_n3530 FE_OFN897_n3531
+ router_addr_calc_fir_write_calc_counter_N77 AOI22X1TS
XU532 n3661 n7487 FE_OFN877_n3662 FE_OFN875_n3663
+ router_addr_calc_fft_read_calc_counter_N77 AOI22X1TS
XU2517 n4743 n7584 n4746 FE_OFN642_n4741 OAI21X1TS
XU306 router_addr_calc_fir_write_calc_counter_N209 n9407 n3529 NAND2XLTS
XU2509 n6635 FE_OFN640_n4741 FE_OFN1787_acc_fir_data_in_4_ FE_OFN632_n4742
+ fifo_from_fir_fifo_cell4_sr_out[4] AO22XLTS
XU2515 n6640 fifo_from_fir_fifo_cell4_controller_valid_read n4743
+ FE_OFN829_n7619 AOI21X1TS
XU2676 n4651 FE_OFN642_n4741 n4652 n4817 NAND3XLTS
XU914 n3862 n3932 n3863 n3988 NAND3XLTS
XU2516 n6641 fifo_from_fir_fifo_cell4_data_out_N35 n4745 n4743 OAI21XLTS
XU1058 n4037 n4107 n4038 n4163 NAND3XLTS
XU1886 n4557 n7509 n4560 FE_OFN301_n4555 OAI21X1TS
XU864 n5498 fifo_to_fft_fifo_cell6_controller_valid_read n3930 FE_OFN834_n7619
+ AOI21X1TS
XU1008 n5550 fifo_to_fir_fifo_cell6_controller_valid_read n4105 FE_OFN811_n7619
+ AOI21X1TS
XU1885 n6112 fifo_from_fft_fifo_cell4_data_out_N35 n4559 n4557 OAI21XLTS
XU2506 n6632 FE_OFN640_n4741 FE_OFN1768_acc_fir_data_in_7_ FE_OFN632_n4742
+ fifo_from_fir_fifo_cell4_sr_out[7] AO22XLTS
XU915 n3987 n8811 n3989 fifo_to_fft_hang[5] n9477 OAI211XLTS
XU1006 n5549 fifo_to_fir_fifo_cell6_data_out_N35 n4104 n4105 OAI21XLTS
XU2507 n6633 FE_OFN645_n4741 FE_OFN1771_acc_fir_data_in_6_ FE_OFN638_n4742
+ fifo_from_fir_fifo_cell4_sr_out[6] AO22XLTS
XU1059 n4162 n8790 n4164 fifo_to_fir_hang[5] n9474 OAI211XLTS
XU1884 n6111 fifo_from_fft_fifo_cell4_controller_valid_read n4557
+ FE_OFN825_n7619 AOI21X1TS
XU2508 n6634 n4741 FE_OFN1779_acc_fir_data_in_5_ FE_OFN632_n4742
+ fifo_from_fir_fifo_cell4_sr_out[5] AO22XLTS
XU2677 n4816 n8876 n4818 fifo_from_fir_hang[3] n9466 OAI211XLTS
XU2045 n4465 n4555 n4466 n4631 NAND3XLTS
XU862 n5497 fifo_to_fft_fifo_cell6_data_out_N35 n3929 n3930 OAI21XLTS
XU1878 n6106 FE_OFN301_n4555 FE_OFN1599_acc_fft_data_in_4_ n4556
+ fifo_from_fft_fifo_cell4_sr_out[4] AO22XLTS
XU2497 n6623 FE_OFN647_n4741 FE_OFN1717_acc_fir_data_in_16_ FE_OFN630_n4742
+ fifo_from_fir_fifo_cell4_sr_out[16] AO22XLTS
XU2495 n6621 FE_OFN649_n4741 FE_OFN1706_acc_fir_data_in_18_ FE_OFN634_n4742
+ fifo_from_fir_fifo_cell4_sr_out[18] AO22XLTS
XU2494 n6620 FE_OFN647_n4741 FE_OFN1699_acc_fir_data_in_19_ n4742
+ fifo_from_fir_fifo_cell4_sr_out[19] AO22XLTS
XU2496 n6622 FE_OFN647_n4741 FE_OFN1711_acc_fir_data_in_17_ FE_OFN630_n4742
+ fifo_from_fir_fifo_cell4_sr_out[17] AO22XLTS
XU2493 n6619 FE_OFN648_n4741 FE_OFN1690_acc_fir_data_in_20_ FE_OFN630_n4742
+ fifo_from_fir_fifo_cell4_sr_out[20] AO22XLTS
XU2513 n6639 FE_OFN646_n4741 FE_OFN1816_acc_fir_data_in_0_ n4742
+ fifo_from_fir_fifo_cell4_sr_out[0] AO22XLTS
XU2492 n6618 FE_OFN648_n4741 FE_OFN1684_acc_fir_data_in_21_ FE_OFN634_n4742
+ fifo_from_fir_fifo_cell4_sr_out[21] AO22XLTS
XU2512 n6638 FE_OFN644_n4741 FE_OFN1803_acc_fir_data_in_1_ FE_OFN631_n4742
+ fifo_from_fir_fifo_cell4_sr_out[1] AO22XLTS
XU2510 n6636 FE_OFN644_n4741 FE_OFN1794_acc_fir_data_in_3_ FE_OFN631_n4742
+ fifo_from_fir_fifo_cell4_sr_out[3] AO22XLTS
XU2511 n6637 FE_OFN644_n4741 FE_OFN1801_acc_fir_data_in_2_ FE_OFN631_n4742
+ fifo_from_fir_fifo_cell4_sr_out[2] AO22XLTS
XU2490 n6616 FE_OFN648_n4741 FE_OFN1677_acc_fir_data_in_23_ FE_OFN634_n4742
+ fifo_from_fir_fifo_cell4_sr_out[23] AO22XLTS
XU2491 n6617 FE_OFN651_n4741 FE_OFN1682_acc_fir_data_in_22_ FE_OFN639_n4742
+ fifo_from_fir_fifo_cell4_sr_out[22] AO22XLTS
XU860 n3925 n7301 n3923 n3927 OAI21XLTS
XU1875 n6103 FE_OFN308_n4555 FE_OFN1581_acc_fft_data_in_7_ FE_OFN299_n4556
+ fifo_from_fft_fifo_cell4_sr_out[7] AO22XLTS
XU1876 n6104 FE_OFN303_n4555 FE_OFN1587_acc_fft_data_in_6_ FE_OFN291_n4556
+ fifo_from_fft_fifo_cell4_sr_out[6] AO22XLTS
XU1004 n4100 n7410 n4098 n4102 OAI21XLTS
XU2046 n4630 n8843 n4632 fifo_from_fft_hang[3] n9470 OAI211XLTS
XU1877 n6105 FE_OFN305_n4555 FE_OFN1593_acc_fft_data_in_5_ FE_OFN294_n4556
+ fifo_from_fft_fifo_cell4_sr_out[5] AO22XLTS
XU1056 n4039 n4102 n4040 n4160 NAND3XLTS
XU1881 n6109 FE_OFN305_n4555 FE_OFN1615_acc_fft_data_in_1_ FE_OFN294_n4556
+ fifo_from_fft_fifo_cell4_sr_out[1] AO22XLTS
XU857 n5494 fifo_to_fft_fifo_cell7_data_out_N35 n3924 n3925 OAI21XLTS
XU1879 n6107 FE_OFN309_n4555 FE_OFN1603_acc_fft_data_in_3_ FE_OFN300_n4556
+ fifo_from_fft_fifo_cell4_sr_out[3] AO22XLTS
XU1880 n6108 FE_OFN308_n4555 FE_OFN1608_acc_fft_data_in_2_ FE_OFN299_n4556
+ fifo_from_fft_fifo_cell4_sr_out[2] AO22XLTS
XU1882 n6110 FE_OFN309_n4555 FE_OFN1627_acc_fft_data_in_0_ FE_OFN300_n4556
+ fifo_from_fft_fifo_cell4_sr_out[0] AO22XLTS
XU2499 n6625 FE_OFN651_n4741 FE_OFN1730_acc_fir_data_in_14_ FE_OFN639_n4742
+ fifo_from_fir_fifo_cell4_sr_out[14] AO22XLTS
XU2500 n6626 FE_OFN649_n4741 FE_OFN1735_acc_fir_data_in_13_ FE_OFN633_n4742
+ fifo_from_fir_fifo_cell4_sr_out[13] AO22XLTS
XU2501 n6627 FE_OFN651_n4741 FE_OFN1739_acc_fir_data_in_12_ FE_OFN639_n4742
+ fifo_from_fir_fifo_cell4_sr_out[12] AO22XLTS
XU1001 n5546 fifo_to_fir_fifo_cell7_data_out_N35 n4099 n4100 OAI21XLTS
XU2502 n6628 FE_OFN649_n4741 FE_OFN1744_acc_fir_data_in_11_ FE_OFN633_n4742
+ fifo_from_fir_fifo_cell4_sr_out[11] AO22XLTS
XU2503 n6629 FE_OFN650_n4741 FE_OFN1749_acc_fir_data_in_10_ FE_OFN636_n4742
+ fifo_from_fir_fifo_cell4_sr_out[10] AO22XLTS
XU2504 n6630 FE_OFN650_n4741 FE_OFN1754_acc_fir_data_in_9_ FE_OFN636_n4742
+ fifo_from_fir_fifo_cell4_sr_out[9] AO22XLTS
XU912 n3864 n3927 n3865 n3985 NAND3XLTS
XU1861 n6089 FE_OFN306_n4555 FE_OFN1508_acc_fft_data_in_21_ FE_OFN295_n4556
+ fifo_from_fft_fifo_cell4_sr_out[21] AO22XLTS
XU1003 n5547 fifo_to_fir_fifo_cell7_controller_valid_read n4100 FE_OFN800_n7619
+ AOI21X1TS
XU1862 n6090 FE_OFN310_n4555 FE_OFN1510_acc_fft_data_in_20_ FE_OFN293_n4556
+ fifo_from_fft_fifo_cell4_sr_out[20] AO22XLTS
XU1864 n6092 FE_OFN302_n4555 FE_OFN1523_acc_fft_data_in_18_ n4556
+ fifo_from_fft_fifo_cell4_sr_out[18] AO22XLTS
XU2484 n6610 FE_OFN645_n4741 FE_OFN1645_acc_fir_data_in_29_ FE_OFN638_n4742
+ fifo_from_fir_fifo_cell4_sr_out[29] AO22XLTS
XU1863 n6091 FE_OFN302_n4555 FE_OFN1518_acc_fft_data_in_19_ n4556
+ fifo_from_fft_fifo_cell4_sr_out[19] AO22XLTS
XU1859 n6087 FE_OFN303_n4555 FE_OFN1494_acc_fft_data_in_23_ FE_OFN291_n4556
+ fifo_from_fft_fifo_cell4_sr_out[23] AO22XLTS
XU2486 n6612 FE_OFN643_n4741 FE_OFN1655_acc_fir_data_in_27_ FE_OFN635_n4742
+ fifo_from_fir_fifo_cell4_sr_out[27] AO22XLTS
XU2482 n6608 FE_OFN645_n4741 FE_OFN1631_acc_fir_data_in_31_ FE_OFN638_n4742
+ fifo_from_fir_fifo_cell4_sr_out[31] AO22XLTS
XU859 n5495 fifo_to_fft_fifo_cell7_controller_valid_read n3925 FE_OFN797_n7619
+ AOI21X1TS
XU2489 n6615 FE_OFN641_n4741 FE_OFN1670_acc_fir_data_in_24_ FE_OFN637_n4742
+ fifo_from_fir_fifo_cell4_sr_out[24] AO22XLTS
XU2488 n6614 FE_OFN643_n4741 FE_OFN1665_acc_fir_data_in_25_ FE_OFN637_n4742
+ fifo_from_fir_fifo_cell4_sr_out[25] AO22XLTS
XU2487 n6613 FE_OFN641_n4741 FE_OFN1658_acc_fir_data_in_26_ FE_OFN637_n4742
+ fifo_from_fir_fifo_cell4_sr_out[26] AO22XLTS
XU2483 n6609 FE_OFN643_n4741 FE_OFN1637_acc_fir_data_in_30_ FE_OFN635_n4742
+ fifo_from_fir_fifo_cell4_sr_out[30] AO22XLTS
XU2505 n6631 FE_OFN650_n4741 FE_OFN1761_acc_fir_data_in_8_ FE_OFN636_n4742
+ fifo_from_fir_fifo_cell4_sr_out[8] AO22XLTS
XU1860 n6088 FE_OFN306_n4555 FE_OFN1503_acc_fft_data_in_22_ FE_OFN295_n4556
+ fifo_from_fft_fifo_cell4_sr_out[22] AO22XLTS
XU1865 n6093 FE_OFN312_n4555 FE_OFN1528_acc_fft_data_in_17_ FE_OFN297_n4556
+ fifo_from_fft_fifo_cell4_sr_out[17] AO22XLTS
XU1866 n6094 FE_OFN312_n4555 FE_OFN1533_acc_fft_data_in_16_ FE_OFN297_n4556
+ fifo_from_fft_fifo_cell4_sr_out[16] AO22XLTS
XU2485 n6611 FE_OFN645_n4741 FE_OFN1650_acc_fir_data_in_28_ FE_OFN638_n4742
+ fifo_from_fir_fifo_cell4_sr_out[28] AO22XLTS
XU1852 n6080 FE_OFN309_n4555 FE_OFN1462_acc_fft_data_in_30_ FE_OFN300_n4556
+ fifo_from_fft_fifo_cell4_sr_out[30] AO22XLTS
XU1853 n6081 FE_OFN309_n4555 FE_OFN1467_acc_fft_data_in_29_ FE_OFN300_n4556
+ fifo_from_fft_fifo_cell4_sr_out[29] AO22XLTS
XU1854 n6082 FE_OFN304_n4555 FE_OFN1471_acc_fft_data_in_28_ FE_OFN295_n4556
+ fifo_from_fft_fifo_cell4_sr_out[28] AO22XLTS
XU913 n3984 n8810 n3986 fifo_to_fft_hang[6] n9478 OAI211XLTS
XU1851 n6079 FE_OFN304_n4555 FE_OFN1454_acc_fft_data_in_31_ FE_OFN295_n4556
+ fifo_from_fft_fifo_cell4_sr_out[31] AO22XLTS
XU1857 n6085 FE_OFN308_n4555 FE_OFN1483_acc_fft_data_in_25_ FE_OFN299_n4556
+ fifo_from_fft_fifo_cell4_sr_out[25] AO22XLTS
XU1855 n6083 FE_OFN307_n4555 FE_OFN1473_acc_fft_data_in_27_ FE_OFN298_n4556
+ fifo_from_fft_fifo_cell4_sr_out[27] AO22XLTS
XU1872 n6100 FE_OFN306_n4555 FE_OFN1567_acc_fft_data_in_10_ FE_OFN292_n4556
+ fifo_from_fft_fifo_cell4_sr_out[10] AO22XLTS
XU1858 n6086 FE_OFN308_n4555 FE_OFN1488_acc_fft_data_in_24_ FE_OFN299_n4556
+ fifo_from_fft_fifo_cell4_sr_out[24] AO22XLTS
XU1870 n6098 FE_OFN312_n4555 FE_OFN1555_acc_fft_data_in_12_ FE_OFN297_n4556
+ fifo_from_fft_fifo_cell4_sr_out[12] AO22XLTS
XU1873 n6101 FE_OFN310_n4555 FE_OFN1570_acc_fft_data_in_9_ FE_OFN296_n4556
+ fifo_from_fft_fifo_cell4_sr_out[9] AO22XLTS
XU1057 n4159 n8789 n4161 fifo_to_fir_hang[6] n9474 OAI211XLTS
XU1868 n6096 FE_OFN312_n4555 FE_OFN1543_acc_fft_data_in_14_ FE_OFN297_n4556
+ fifo_from_fft_fifo_cell4_sr_out[14] AO22XLTS
XU1871 n6099 FE_OFN310_n4555 FE_OFN1563_acc_fft_data_in_11_ FE_OFN296_n4556
+ fifo_from_fft_fifo_cell4_sr_out[11] AO22XLTS
XU1869 n6097 FE_OFN311_n4555 FE_OFN1548_acc_fft_data_in_13_ FE_OFN296_n4556
+ fifo_from_fft_fifo_cell4_sr_out[13] AO22XLTS
XU1874 n6102 FE_OFN311_n4555 FE_OFN1575_acc_fft_data_in_8_ FE_OFN296_n4556
+ fifo_from_fft_fifo_cell4_sr_out[8] AO22XLTS
XU1856 n6084 FE_OFN307_n4555 FE_OFN1479_acc_fft_data_in_26_ FE_OFN298_n4556
+ fifo_from_fft_fifo_cell4_sr_out[26] AO22XLTS
XU2480 n4737 n7579 n4740 FE_OFN618_n4735 OAI21X1TS
XU1849 n4551 n7504 n4554 n4549 OAI21XLTS
XU2478 n6606 fifo_from_fir_fifo_cell5_controller_valid_read n4737
+ FE_OFN829_n7619 AOI21X1TS
XU2674 n4653 FE_OFN618_n4735 n4654 n4814 NAND3XLTS
XU2479 n6607 fifo_from_fir_fifo_cell5_data_out_N35 n4739 n4737 OAI21XLTS
XU1848 n6078 fifo_from_fft_fifo_cell5_data_out_N35 n4553 n4551 OAI21XLTS
XU2463 n6592 FE_OFN627_n4735 FE_OFN1734_acc_fir_data_in_13_ FE_OFN374_n4736
+ fifo_from_fir_fifo_cell5_sr_out[13] AO22XLTS
XU2043 n4467 n4549 n4468 n4628 NAND3XLTS
XU2446 n6575 FE_OFN624_n4735 FE_OFN1636_acc_fir_data_in_30_ FE_OFN375_n4736
+ fifo_from_fir_fifo_cell5_sr_out[30] AO22XLTS
XU2464 n6593 FE_OFN629_n4735 FE_OFN1739_acc_fir_data_in_12_ FE_OFN378_n4736
+ fifo_from_fir_fifo_cell5_sr_out[12] AO22XLTS
XU2461 n6590 FE_OFN629_n4735 FE_OFN1723_acc_fir_data_in_15_ FE_OFN378_n4736
+ fifo_from_fir_fifo_cell5_sr_out[15] AO22XLTS
XU2448 n6577 FE_OFN623_n4735 FE_OFN1649_acc_fir_data_in_28_ FE_OFN375_n4736
+ fifo_from_fir_fifo_cell5_sr_out[28] AO22XLTS
XU2447 n6576 FE_OFN623_n4735 FE_OFN1644_acc_fir_data_in_29_ FE_OFN375_n4736
+ fifo_from_fir_fifo_cell5_sr_out[29] AO22XLTS
XU2462 n6591 FE_OFN629_n4735 FE_OFN1730_acc_fir_data_in_14_ FE_OFN378_n4736
+ fifo_from_fir_fifo_cell5_sr_out[14] AO22XLTS
XU2445 n6574 FE_OFN623_n4735 FE_OFN1630_acc_fir_data_in_31_ FE_OFN373_n4736
+ fifo_from_fir_fifo_cell5_sr_out[31] AO22XLTS
XU1847 n6077 fifo_from_fft_fifo_cell5_controller_valid_read n4551
+ FE_OFN832_n7619 AOI21X1TS
XU2675 n4813 n8876 n4815 fifo_from_fir_hang[4] n9466 OAI211XLTS
XU2476 n6605 FE_OFN619_n4735 FE_OFN1813_acc_fir_data_in_0_ FE_OFN370_n4736
+ fifo_from_fir_fifo_cell5_sr_out[0] AO22XLTS
XU2471 n6600 n4735 FE_OFN1780_acc_fir_data_in_5_ FE_OFN372_n4736
+ fifo_from_fir_fifo_cell5_sr_out[5] AO22XLTS
XU2472 n6601 n4735 FE_OFN1787_acc_fir_data_in_4_ FE_OFN372_n4736
+ fifo_from_fir_fifo_cell5_sr_out[4] AO22XLTS
XU2473 n6602 FE_OFN621_n4735 FE_OFN1793_acc_fir_data_in_3_ FE_OFN370_n4736
+ fifo_from_fir_fifo_cell5_sr_out[3] AO22XLTS
XU2468 n6597 FE_OFN628_n4735 FE_OFN1761_acc_fir_data_in_8_ FE_OFN376_n4736
+ fifo_from_fir_fifo_cell5_sr_out[8] AO22XLTS
XU1814 n6045 FE_OFN285_n4549 FE_OFN1454_acc_fft_data_in_31_ FE_OFN36_n4550
+ fifo_from_fft_fifo_cell5_sr_out[31] AO22XLTS
XU2466 n6595 FE_OFN628_n4735 FE_OFN1749_acc_fir_data_in_10_ FE_OFN376_n4736
+ fifo_from_fir_fifo_cell5_sr_out[10] AO22XLTS
XU2465 n6594 FE_OFN627_n4735 FE_OFN1744_acc_fir_data_in_11_ FE_OFN374_n4736
+ fifo_from_fir_fifo_cell5_sr_out[11] AO22XLTS
XU2470 n6599 FE_OFN620_n4735 FE_OFN1771_acc_fir_data_in_6_ FE_OFN373_n4736
+ fifo_from_fir_fifo_cell5_sr_out[6] AO22XLTS
XU2475 n6604 FE_OFN621_n4735 FE_OFN1806_acc_fir_data_in_1_ FE_OFN370_n4736
+ fifo_from_fir_fifo_cell5_sr_out[1] AO22XLTS
XU1815 n6046 FE_OFN286_n4549 FE_OFN1459_acc_fft_data_in_30_ FE_OFN35_n4550
+ fifo_from_fft_fifo_cell5_sr_out[30] AO22XLTS
XU2474 n6603 FE_OFN619_n4735 FE_OFN1800_acc_fir_data_in_2_ FE_OFN372_n4736
+ fifo_from_fir_fifo_cell5_sr_out[2] AO22XLTS
XU2460 n6589 FE_OFN625_n4735 FE_OFN1718_acc_fir_data_in_16_ FE_OFN371_n4736
+ fifo_from_fir_fifo_cell5_sr_out[16] AO22XLTS
XU2467 n6596 FE_OFN628_n4735 FE_OFN1754_acc_fir_data_in_9_ FE_OFN376_n4736
+ fifo_from_fir_fifo_cell5_sr_out[9] AO22XLTS
XU2459 n6588 FE_OFN622_n4735 FE_OFN1710_acc_fir_data_in_17_ FE_OFN369_n4736
+ fifo_from_fir_fifo_cell5_sr_out[17] AO22XLTS
XU1830 n6061 FE_OFN282_n4549 FE_OFN1539_acc_fft_data_in_15_ FE_OFN39_n4550
+ fifo_from_fft_fifo_cell5_sr_out[15] AO22XLTS
XU2044 n4627 n8843 n4629 fifo_from_fft_hang[4] n9468 OAI211XLTS
XU2458 n6587 FE_OFN627_n4735 FE_OFN1705_acc_fir_data_in_18_ FE_OFN374_n4736
+ fifo_from_fir_fifo_cell5_sr_out[18] AO22XLTS
XU2457 n6586 FE_OFN622_n4735 FE_OFN1701_acc_fir_data_in_19_ FE_OFN369_n4736
+ fifo_from_fir_fifo_cell5_sr_out[19] AO22XLTS
XU2456 n6585 FE_OFN622_n4735 FE_OFN1694_acc_fir_data_in_20_ FE_OFN369_n4736
+ fifo_from_fir_fifo_cell5_sr_out[20] AO22XLTS
XU2455 n6584 FE_OFN625_n4735 FE_OFN1683_acc_fir_data_in_21_ FE_OFN371_n4736
+ fifo_from_fir_fifo_cell5_sr_out[21] AO22XLTS
XU2469 n6598 FE_OFN620_n4735 FE_OFN1765_acc_fir_data_in_7_ FE_OFN373_n4736
+ fifo_from_fir_fifo_cell5_sr_out[7] AO22XLTS
XU2454 n6583 FE_OFN629_n4735 FE_OFN1682_acc_fir_data_in_22_ FE_OFN378_n4736
+ fifo_from_fir_fifo_cell5_sr_out[22] AO22XLTS
XU2453 n6582 FE_OFN625_n4735 FE_OFN1672_acc_fir_data_in_23_ FE_OFN371_n4736
+ fifo_from_fir_fifo_cell5_sr_out[23] AO22XLTS
XU1816 n6047 FE_OFN286_n4549 FE_OFN1465_acc_fft_data_in_29_ FE_OFN36_n4550
+ fifo_from_fft_fifo_cell5_sr_out[29] AO22XLTS
XU1817 n6048 FE_OFN285_n4549 FE_OFN1820_acc_fft_data_in_28_ FE_OFN36_n4550
+ fifo_from_fft_fifo_cell5_sr_out[28] AO22XLTS
XU2452 n6581 FE_OFN626_n4735 FE_OFN1668_acc_fir_data_in_24_ FE_OFN377_n4736
+ fifo_from_fir_fifo_cell5_sr_out[24] AO22XLTS
XU1831 n6062 FE_OFN282_n4549 FE_OFN1544_acc_fft_data_in_14_ FE_OFN40_n4550
+ fifo_from_fft_fifo_cell5_sr_out[14] AO22XLTS
XU2451 n6580 FE_OFN626_n4735 FE_OFN1662_acc_fir_data_in_25_ FE_OFN377_n4736
+ fifo_from_fir_fifo_cell5_sr_out[25] AO22XLTS
XU2450 n6579 FE_OFN624_n4735 FE_OFN1660_acc_fir_data_in_26_ FE_OFN377_n4736
+ fifo_from_fir_fifo_cell5_sr_out[26] AO22XLTS
XU1833 n6064 FE_OFN280_n4549 FE_OFN1555_acc_fft_data_in_12_ FE_OFN41_n4550
+ fifo_from_fft_fifo_cell5_sr_out[12] AO22XLTS
XU1832 n6063 FE_OFN282_n4549 FE_OFN1550_acc_fft_data_in_13_ FE_OFN39_n4550
+ fifo_from_fft_fifo_cell5_sr_out[13] AO22XLTS
XU2449 n6578 FE_OFN624_n4735 FE_OFN1654_acc_fir_data_in_27_ FE_OFN377_n4736
+ fifo_from_fir_fifo_cell5_sr_out[27] AO22XLTS
XU1823 n6054 FE_OFN284_n4549 FE_OFN1499_acc_fft_data_in_22_ FE_OFN37_n4550
+ fifo_from_fft_fifo_cell5_sr_out[22] AO22XLTS
XU1845 n6076 FE_OFN286_n4549 FE_OFN1627_acc_fft_data_in_0_ FE_OFN35_n4550
+ fifo_from_fft_fifo_cell5_sr_out[0] AO22XLTS
XU1829 n6060 FE_OFN280_n4549 FE_OFN1534_acc_fft_data_in_16_ FE_OFN41_n4550
+ fifo_from_fft_fifo_cell5_sr_out[16] AO22XLTS
XU1824 n6055 FE_OFN285_n4549 FE_OFN1506_acc_fft_data_in_21_ FE_OFN37_n4550
+ fifo_from_fft_fifo_cell5_sr_out[21] AO22XLTS
XU1836 n6067 FE_OFN283_n4549 FE_OFN1570_acc_fft_data_in_9_ FE_OFN38_n4550
+ fifo_from_fft_fifo_cell5_sr_out[9] AO22XLTS
XU1844 n6075 FE_OFN288_n4549 FE_OFN1617_acc_fft_data_in_1_ FE_OFN34_n4550
+ fifo_from_fft_fifo_cell5_sr_out[1] AO22XLTS
XU1839 n6070 FE_OFN281_n4549 FE_OFN1585_acc_fft_data_in_6_ FE_OFN42_n4550
+ fifo_from_fft_fifo_cell5_sr_out[6] AO22XLTS
XU1826 n6057 FE_OFN279_n4549 FE_OFN1516_acc_fft_data_in_19_ FE_OFN42_n4550
+ fifo_from_fft_fifo_cell5_sr_out[19] AO22XLTS
XU1837 n6068 FE_OFN283_n4549 FE_OFN1575_acc_fft_data_in_8_ FE_OFN38_n4550
+ fifo_from_fft_fifo_cell5_sr_out[8] AO22XLTS
XU1842 n6073 FE_OFN287_n4549 FE_OFN1606_acc_fft_data_in_3_ FE_OFN35_n4550
+ fifo_from_fft_fifo_cell5_sr_out[3] AO22XLTS
XU1835 n6066 FE_OFN284_n4549 FE_OFN1566_acc_fft_data_in_10_ FE_OFN38_n4550
+ fifo_from_fft_fifo_cell5_sr_out[10] AO22XLTS
XU910 n3866 n7295 n3867 n3982 NAND3XLTS
XU1818 n6049 FE_OFN287_n4549 FE_OFN1475_acc_fft_data_in_27_ FE_OFN34_n4550
+ fifo_from_fft_fifo_cell5_sr_out[27] AO22XLTS
XU1838 n6069 FE_OFN290_n4549 FE_OFN1581_acc_fft_data_in_7_ n4550
+ fifo_from_fft_fifo_cell5_sr_out[7] AO22XLTS
XU1820 n6051 FE_OFN289_n4549 FE_OFN1486_acc_fft_data_in_25_ FE_OFN33_n4550
+ fifo_from_fft_fifo_cell5_sr_out[25] AO22XLTS
XU1841 n6072 FE_OFN290_n4549 FE_OFN1600_acc_fft_data_in_4_ n4550
+ fifo_from_fft_fifo_cell5_sr_out[4] AO22XLTS
XU996 n5543 fifo_to_fir_fifo_cell8_data_out_N35 n4094 n4095 OAI21XLTS
XU1843 n6074 FE_OFN288_n4549 FE_OFN1610_acc_fft_data_in_2_ FE_OFN33_n4550
+ fifo_from_fft_fifo_cell5_sr_out[2] AO22XLTS
XU1840 n6071 FE_OFN281_n4549 FE_OFN1591_acc_fft_data_in_5_ FE_OFN42_n4550
+ fifo_from_fft_fifo_cell5_sr_out[5] AO22XLTS
XU1821 n6052 FE_OFN288_n4549 FE_OFN1489_acc_fft_data_in_24_ FE_OFN33_n4550
+ fifo_from_fft_fifo_cell5_sr_out[24] AO22XLTS
XU1828 n6059 FE_OFN280_n4549 FE_OFN1528_acc_fft_data_in_17_ FE_OFN41_n4550
+ fifo_from_fft_fifo_cell5_sr_out[17] AO22XLTS
XU1834 n6065 FE_OFN283_n4549 FE_OFN1563_acc_fft_data_in_11_ FE_OFN39_n4550
+ fifo_from_fft_fifo_cell5_sr_out[11] AO22XLTS
XU1819 n6050 FE_OFN287_n4549 FE_OFN1480_acc_fft_data_in_26_ FE_OFN34_n4550
+ fifo_from_fft_fifo_cell5_sr_out[26] AO22XLTS
XU1827 n6058 FE_OFN281_n4549 FE_OFN1526_acc_fft_data_in_18_ FE_OFN40_n4550
+ fifo_from_fft_fifo_cell5_sr_out[18] AO22XLTS
XU1825 n6056 FE_OFN284_n4549 FE_OFN1514_acc_fft_data_in_20_ FE_OFN37_n4550
+ fifo_from_fft_fifo_cell5_sr_out[20] AO22XLTS
XU852 n5491 fifo_to_fft_fifo_cell8_data_out_N35 n3919 n3920 OAI21XLTS
XU1822 n6053 FE_OFN281_n4549 FE_OFN1493_acc_fft_data_in_23_ FE_OFN42_n4550
+ fifo_from_fft_fifo_cell5_sr_out[23] AO22XLTS
XU1054 n4041 n7404 n4042 n4157 NAND3XLTS
XU1055 n4156 n8789 n4158 fifo_to_fir_hang[7] n9475 OAI211XLTS
XU911 n3981 n8810 n3983 fifo_to_fft_hang[7] n9479 OAI211XLTS
XU2443 n4731 n7574 n4734 n4729 OAI21XLTS
XU1812 n4545 n7499 n4548 n4543 OAI21XLTS
XU2672 n4655 n4729 n4656 n4811 NAND3XLTS
XU2418 n6550 FE_OFN614_n4729 FE_OFN1684_acc_fir_data_in_21_ FE_OFN381_n4730
+ fifo_from_fir_fifo_cell6_sr_out[21] AO22XLTS
XU2441 n6572 fifo_from_fir_fifo_cell6_controller_valid_read n4731
+ FE_OFN822_n7619 AOI21X1TS
XU2442 n6573 fifo_from_fir_fifo_cell6_data_out_N35 n4733 n4731 OAI21XLTS
XU2417 n6549 FE_OFN617_n4729 FE_OFN1681_acc_fir_data_in_22_ FE_OFN389_n4730
+ fifo_from_fir_fifo_cell6_sr_out[22] AO22XLTS
XU2419 n6551 FE_OFN610_n4729 FE_OFN1690_acc_fir_data_in_20_ FE_OFN381_n4730
+ fifo_from_fir_fifo_cell6_sr_out[20] AO22XLTS
XU2416 n6548 FE_OFN610_n4729 FE_OFN1677_acc_fir_data_in_23_ FE_OFN381_n4730
+ fifo_from_fir_fifo_cell6_sr_out[23] AO22XLTS
XU1810 n6043 fifo_from_fft_fifo_cell6_controller_valid_read n4545
+ FE_OFN832_n7619 AOI21X1TS
XU2408 n6540 FE_OFN613_n4729 FE_OFN1629_acc_fir_data_in_31_ FE_OFN388_n4730
+ fifo_from_fir_fifo_cell6_sr_out[31] AO22XLTS
XU1786 n6020 FE_OFN275_n4543 FE_OFN1499_acc_fft_data_in_22_ FE_OFN265_n4544
+ fifo_from_fft_fifo_cell6_sr_out[22] AO22XLTS
XU1811 n6044 fifo_from_fft_fifo_cell6_data_out_N35 n4547 n4545 OAI21XLTS
XU1787 n6021 FE_OFN275_n4543 FE_OFN1506_acc_fft_data_in_21_ FE_OFN264_n4544
+ fifo_from_fft_fifo_cell6_sr_out[21] AO22XLTS
XU2410 n6542 FE_OFN613_n4729 FE_OFN1640_acc_fir_data_in_29_ FE_OFN388_n4730
+ fifo_from_fir_fifo_cell6_sr_out[29] AO22XLTS
XU2409 n6541 FE_OFN613_n4729 FE_OFN1634_acc_fir_data_in_30_ FE_OFN388_n4730
+ fifo_from_fir_fifo_cell6_sr_out[30] AO22XLTS
XU2673 n4810 n8876 n4812 fifo_from_fir_hang[5] n9467 OAI211XLTS
XU2041 n4469 n4543 n4470 n4625 NAND3XLTS
XU908 n3868 n7285 n3869 n3979 NAND3XLTS
XU1779 n6013 FE_OFN277_n4543 FE_OFN1463_acc_fft_data_in_29_ FE_OFN263_n4544
+ fifo_from_fft_fifo_cell6_sr_out[29] AO22XLTS
XU1785 n6019 FE_OFN271_n4543 FE_OFN1495_acc_fft_data_in_23_ FE_OFN265_n4544
+ fifo_from_fft_fifo_cell6_sr_out[23] AO22XLTS
XU1788 n6022 FE_OFN271_n4543 FE_OFN1513_acc_fft_data_in_20_ FE_OFN265_n4544
+ fifo_from_fft_fifo_cell6_sr_out[20] AO22XLTS
XU1778 n6012 FE_OFN277_n4543 FE_OFN1459_acc_fft_data_in_30_ FE_OFN263_n4544
+ fifo_from_fft_fifo_cell6_sr_out[30] AO22XLTS
XU847 n5488 fifo_to_fft_fifo_cell9_data_out_N35 n3914 n3915 OAI21XLTS
XU2422 n6554 FE_OFN614_n4729 FE_OFN1708_acc_fir_data_in_17_ FE_OFN383_n4730
+ fifo_from_fir_fifo_cell6_sr_out[17] AO22XLTS
XU2411 n6543 FE_OFN613_n4729 FE_OFN1647_acc_fir_data_in_28_ FE_OFN388_n4730
+ fifo_from_fir_fifo_cell6_sr_out[28] AO22XLTS
XU2423 n6555 FE_OFN614_n4729 FE_OFN1715_acc_fir_data_in_16_ FE_OFN383_n4730
+ fifo_from_fir_fifo_cell6_sr_out[16] AO22XLTS
XU2042 n4624 n8843 n4626 fifo_from_fft_hang[5] n9470 OAI211XLTS
XU2421 n6553 FE_OFN615_n4729 FE_OFN1704_acc_fir_data_in_18_ FE_OFN384_n4730
+ fifo_from_fir_fifo_cell6_sr_out[18] AO22XLTS
XU991 n5540 fifo_to_fir_fifo_cell9_data_out_N35 n4089 n4090 OAI21XLTS
XU1777 n6011 FE_OFN277_n4543 FE_OFN1457_acc_fft_data_in_31_ FE_OFN264_n4544
+ fifo_from_fft_fifo_cell6_sr_out[31] AO22XLTS
XU2420 n6552 FE_OFN610_n4729 FE_OFN1701_acc_fir_data_in_19_ FE_OFN379_n4730
+ fifo_from_fir_fifo_cell6_sr_out[19] AO22XLTS
XU1052 n4043 n7394 n4044 n4154 NAND3XLTS
XU1790 n6024 FE_OFN267_n4543 FE_OFN1526_acc_fft_data_in_18_ FE_OFN257_n4544
+ fifo_from_fft_fifo_cell6_sr_out[18] AO22XLTS
XU1791 n6025 FE_OFN266_n4543 FE_OFN1527_acc_fft_data_in_17_ FE_OFN257_n4544
+ fifo_from_fft_fifo_cell6_sr_out[17] AO22XLTS
XU1792 n6026 FE_OFN266_n4543 FE_OFN1534_acc_fft_data_in_16_ FE_OFN257_n4544
+ fifo_from_fft_fifo_cell6_sr_out[16] AO22XLTS
XU1780 n6014 FE_OFN277_n4543 FE_OFN1468_acc_fft_data_in_28_ FE_OFN264_n4544
+ fifo_from_fft_fifo_cell6_sr_out[28] AO22XLTS
XU1053 n4153 n8789 n4155 fifo_to_fir_hang[8] n9475 OAI211XLTS
XU1789 n6023 FE_OFN267_n4543 FE_OFN1517_acc_fft_data_in_19_ n4544
+ fifo_from_fft_fifo_cell6_sr_out[19] AO22XLTS
XU909 n3978 n8810 n3980 fifo_to_fft_hang[8] n9478 OAI211XLTS
XU2439 n6571 FE_OFN608_n4729 FE_OFN1816_acc_fir_data_in_0_ FE_OFN380_n4730
+ fifo_from_fir_fifo_cell6_sr_out[0] AO22XLTS
XU2426 n6558 FE_OFN615_n4729 FE_OFN1732_acc_fir_data_in_13_ FE_OFN384_n4730
+ fifo_from_fir_fifo_cell6_sr_out[13] AO22XLTS
XU2425 n6557 FE_OFN617_n4729 FE_OFN1725_acc_fir_data_in_14_ FE_OFN389_n4730
+ fifo_from_fir_fifo_cell6_sr_out[14] AO22XLTS
XU2438 n6570 FE_OFN606_n4729 FE_OFN1806_acc_fir_data_in_1_ n4730
+ fifo_from_fir_fifo_cell6_sr_out[1] AO22XLTS
XU2437 n6569 FE_OFN609_n4729 FE_OFN1801_acc_fir_data_in_2_ FE_OFN380_n4730
+ fifo_from_fir_fifo_cell6_sr_out[2] AO22XLTS
XU2436 n6568 FE_OFN606_n4729 FE_OFN1793_acc_fir_data_in_3_ n4730
+ fifo_from_fir_fifo_cell6_sr_out[3] AO22XLTS
XU2435 n6567 FE_OFN607_n4729 FE_OFN1787_acc_fir_data_in_4_ FE_OFN382_n4730
+ fifo_from_fir_fifo_cell6_sr_out[4] AO22XLTS
XU2434 n6566 FE_OFN607_n4729 FE_OFN1780_acc_fir_data_in_5_ FE_OFN385_n4730
+ fifo_from_fir_fifo_cell6_sr_out[5] AO22XLTS
XU2433 n6565 FE_OFN609_n4729 FE_OFN1769_acc_fir_data_in_6_ FE_OFN382_n4730
+ fifo_from_fir_fifo_cell6_sr_out[6] AO22XLTS
XU2432 n6564 FE_OFN609_n4729 FE_OFN1763_acc_fir_data_in_7_ FE_OFN382_n4730
+ fifo_from_fir_fifo_cell6_sr_out[7] AO22XLTS
XU2431 n6563 FE_OFN616_n4729 FE_OFN1759_acc_fir_data_in_8_ FE_OFN387_n4730
+ fifo_from_fir_fifo_cell6_sr_out[8] AO22XLTS
XU2430 n6562 FE_OFN616_n4729 FE_OFN1752_acc_fir_data_in_9_ FE_OFN387_n4730
+ fifo_from_fir_fifo_cell6_sr_out[9] AO22XLTS
XU2429 n6561 FE_OFN616_n4729 FE_OFN1749_acc_fir_data_in_10_ FE_OFN387_n4730
+ fifo_from_fir_fifo_cell6_sr_out[10] AO22XLTS
XU2428 n6560 FE_OFN615_n4729 FE_OFN1745_acc_fir_data_in_11_ FE_OFN384_n4730
+ fifo_from_fir_fifo_cell6_sr_out[11] AO22XLTS
XU2427 n6559 FE_OFN617_n4729 FE_OFN1738_acc_fir_data_in_12_ FE_OFN389_n4730
+ fifo_from_fir_fifo_cell6_sr_out[12] AO22XLTS
XU2413 n6545 FE_OFN611_n4729 FE_OFN1659_acc_fir_data_in_26_ FE_OFN386_n4730
+ fifo_from_fir_fifo_cell6_sr_out[26] AO22XLTS
XU2414 n6546 FE_OFN612_n4729 FE_OFN1662_acc_fir_data_in_25_ FE_OFN385_n4730
+ fifo_from_fir_fifo_cell6_sr_out[25] AO22XLTS
XU2424 n6556 FE_OFN617_n4729 FE_OFN1720_acc_fir_data_in_15_ FE_OFN389_n4730
+ fifo_from_fir_fifo_cell6_sr_out[15] AO22XLTS
XU2415 n6547 FE_OFN612_n4729 FE_OFN1667_acc_fir_data_in_24_ FE_OFN385_n4730
+ fifo_from_fir_fifo_cell6_sr_out[24] AO22XLTS
XU2412 n6544 FE_OFN611_n4729 FE_OFN1652_acc_fir_data_in_27_ FE_OFN386_n4730
+ fifo_from_fir_fifo_cell6_sr_out[27] AO22XLTS
XU1808 n6042 FE_OFN278_n4543 FE_OFN1626_acc_fft_data_in_0_ FE_OFN262_n4544
+ fifo_from_fft_fifo_cell6_sr_out[0] AO22XLTS
XU1797 n6031 FE_OFN272_n4543 FE_OFN1563_acc_fft_data_in_11_ FE_OFN261_n4544
+ fifo_from_fft_fifo_cell6_sr_out[11] AO22XLTS
XU1798 n6032 FE_OFN275_n4543 FE_OFN1566_acc_fft_data_in_10_ FE_OFN265_n4544
+ fifo_from_fft_fifo_cell6_sr_out[10] AO22XLTS
XU1795 n6029 FE_OFN272_n4543 FE_OFN1548_acc_fft_data_in_13_ FE_OFN261_n4544
+ fifo_from_fft_fifo_cell6_sr_out[13] AO22XLTS
XU1799 n6033 FE_OFN272_n4543 FE_OFN1569_acc_fft_data_in_9_ FE_OFN261_n4544
+ fifo_from_fft_fifo_cell6_sr_out[9] AO22XLTS
XU845 n3910 n7276 n3908 n3912 OAI21XLTS
XU1784 n6018 FE_OFN273_n4543 FE_OFN1492_acc_fft_data_in_24_ FE_OFN258_n4544
+ fifo_from_fft_fifo_cell6_sr_out[24] AO22XLTS
XU1807 n6041 FE_OFN276_n4543 FE_OFN1620_acc_fft_data_in_1_ FE_OFN259_n4544
+ fifo_from_fft_fifo_cell6_sr_out[1] AO22XLTS
XU1793 n6027 FE_OFN268_n4543 FE_OFN1538_acc_fft_data_in_15_ FE_OFN260_n4544
+ fifo_from_fft_fifo_cell6_sr_out[15] AO22XLTS
XU989 n4085 n7385 n4083 n4087 OAI21XLTS
XU1783 n6017 FE_OFN273_n4543 FE_OFN1487_acc_fft_data_in_25_ FE_OFN258_n4544
+ fifo_from_fft_fifo_cell6_sr_out[25] AO22XLTS
XU1782 n6016 FE_OFN278_n4543 FE_OFN1482_acc_fft_data_in_26_ FE_OFN262_n4544
+ fifo_from_fft_fifo_cell6_sr_out[26] AO22XLTS
XU1801 n6035 FE_OFN270_n4543 FE_OFN1584_acc_fft_data_in_7_ FE_OFN258_n4544
+ fifo_from_fft_fifo_cell6_sr_out[7] AO22XLTS
XU1802 n6036 FE_OFN269_n4543 FE_OFN1589_acc_fft_data_in_6_ FE_OFN256_n4544
+ fifo_from_fft_fifo_cell6_sr_out[6] AO22XLTS
XU1794 n6028 FE_OFN268_n4543 FE_OFN1543_acc_fft_data_in_14_ FE_OFN260_n4544
+ fifo_from_fft_fifo_cell6_sr_out[14] AO22XLTS
XU1806 n6040 FE_OFN276_n4543 FE_OFN1614_acc_fft_data_in_2_ FE_OFN259_n4544
+ fifo_from_fft_fifo_cell6_sr_out[2] AO22XLTS
XU1781 n6015 FE_OFN278_n4543 FE_OFN1477_acc_fft_data_in_27_ FE_OFN259_n4544
+ fifo_from_fft_fifo_cell6_sr_out[27] AO22XLTS
XU1800 n6034 FE_OFN272_n4543 FE_OFN1575_acc_fft_data_in_8_ FE_OFN261_n4544
+ fifo_from_fft_fifo_cell6_sr_out[8] AO22XLTS
XU1796 n6030 FE_OFN268_n4543 FE_OFN1553_acc_fft_data_in_12_ FE_OFN260_n4544
+ fifo_from_fft_fifo_cell6_sr_out[12] AO22XLTS
XU1805 n6039 FE_OFN278_n4543 FE_OFN1607_acc_fft_data_in_3_ FE_OFN262_n4544
+ fifo_from_fft_fifo_cell6_sr_out[3] AO22XLTS
XU2406 n4725 n7569 n4728 FE_OFN593_n4723 OAI21XLTS
XU1803 n6037 FE_OFN271_n4543 FE_OFN1592_acc_fft_data_in_5_ FE_OFN263_n4544
+ fifo_from_fft_fifo_cell6_sr_out[5] AO22XLTS
XU1804 n6038 FE_OFN269_n4543 FE_OFN1600_acc_fft_data_in_4_ FE_OFN256_n4544
+ fifo_from_fft_fifo_cell6_sr_out[4] AO22XLTS
XU2670 n4657 FE_OFN593_n4723 n4658 n4808 NAND3XLTS
XU1775 n4539 n7494 n4542 FE_OFN247_n4537 OAI21XLTS
XU1050 n4045 n4087 n4046 n4151 NAND3XLTS
XU986 n5537 fifo_to_fir_fifo_cell10_data_out_N35 n4084 n4085 OAI21XLTS
XU906 n3870 n3912 n3871 n3976 NAND3XLTS
XU2405 n6539 fifo_from_fir_fifo_cell7_data_out_N35 n4727 n4725 OAI21XLTS
XU844 n5486 fifo_to_fft_fifo_cell10_controller_valid_read n3910 FE_OFN842_n7619
+ AOI21X1TS
XU842 n5485 fifo_to_fft_fifo_cell10_data_out_N35 n3909 n3910 OAI21XLTS
XU988 n5538 fifo_to_fir_fifo_cell10_controller_valid_read n4085 FE_OFN800_n7619
+ AOI21X1TS
XU2404 n6538 fifo_from_fir_fifo_cell7_controller_valid_read n4725
+ FE_OFN829_n7619 AOI21X1TS
XU2372 n6507 FE_OFN600_n4723 FE_OFN1636_acc_fir_data_in_30_ FE_OFN586_n4724
+ fifo_from_fir_fifo_cell7_sr_out[30] AO22XLTS
XU2371 n6506 FE_OFN599_n4723 FE_OFN1628_acc_fir_data_in_31_ FE_OFN588_n4724
+ fifo_from_fir_fifo_cell7_sr_out[31] AO22XLTS
XU2671 n4807 n8875 n4809 fifo_from_fir_hang[6] n9467 OAI211XLTS
XU2387 n6522 FE_OFN605_n4723 FE_OFN1720_acc_fir_data_in_15_ FE_OFN592_n4724
+ fifo_from_fir_fifo_cell7_sr_out[15] AO22XLTS
XU2373 n6508 FE_OFN599_n4723 FE_OFN1640_acc_fir_data_in_29_ FE_OFN588_n4724
+ fifo_from_fir_fifo_cell7_sr_out[29] AO22XLTS
XU1773 n6009 fifo_from_fft_fifo_cell7_controller_valid_read n4539
+ FE_OFN825_n7619 AOI21X1TS
XU907 n3975 n8809 n3977 fifo_to_fft_hang[9] n9479 OAI211XLTS
XU2388 n6523 FE_OFN605_n4723 FE_OFN1725_acc_fir_data_in_14_ FE_OFN592_n4724
+ fifo_from_fir_fifo_cell7_sr_out[14] AO22XLTS
XU2039 n4471 FE_OFN250_n4537 n4472 n4622 NAND3XLTS
XU2389 n6524 FE_OFN601_n4723 FE_OFN1732_acc_fir_data_in_13_ FE_OFN587_n4724
+ fifo_from_fir_fifo_cell7_sr_out[13] AO22XLTS
XU2390 n6525 FE_OFN605_n4723 FE_OFN1738_acc_fir_data_in_12_ FE_OFN592_n4724
+ fifo_from_fir_fifo_cell7_sr_out[12] AO22XLTS
XU1051 n4150 n8788 n4152 fifo_to_fir_hang[9] n9475 OAI211XLTS
XU2374 n6509 FE_OFN599_n4723 FE_OFN1649_acc_fir_data_in_28_ FE_OFN588_n4724
+ fifo_from_fir_fifo_cell7_sr_out[28] AO22XLTS
XU1774 n6010 fifo_from_fft_fifo_cell7_data_out_N35 n4541 n4539 OAI21XLTS
XU1743 n5980 FE_OFN254_n4537 FE_OFN1468_acc_fft_data_in_28_ FE_OFN51_n4538
+ fifo_from_fft_fifo_cell7_sr_out[28] AO22XLTS
XU2401 n6536 n4723 FE_OFN1807_acc_fir_data_in_1_ n4724
+ fifo_from_fir_fifo_cell7_sr_out[1] AO22XLTS
XU1741 n5978 FE_OFN253_n4537 FE_OFN1460_acc_fft_data_in_30_ FE_OFN49_n4538
+ fifo_from_fft_fifo_cell7_sr_out[30] AO22XLTS
XU1740 n5977 FE_OFN253_n4537 FE_OFN1455_acc_fft_data_in_31_ FE_OFN49_n4538
+ fifo_from_fft_fifo_cell7_sr_out[31] AO22XLTS
XU2040 n4621 n8842 n4623 fifo_from_fft_hang[6] n9471 OAI211XLTS
XU2399 n6534 FE_OFN594_n4723 FE_OFN1790_acc_fir_data_in_3_ FE_OFN583_n4724
+ fifo_from_fir_fifo_cell7_sr_out[3] AO22XLTS
XU2384 n6519 FE_OFN601_n4723 FE_OFN1702_acc_fir_data_in_18_ FE_OFN587_n4724
+ fifo_from_fir_fifo_cell7_sr_out[18] AO22XLTS
XU2380 n6515 FE_OFN605_n4723 FE_OFN1682_acc_fir_data_in_22_ FE_OFN592_n4724
+ fifo_from_fir_fifo_cell7_sr_out[22] AO22XLTS
XU1756 n5993 FE_OFN246_n4537 FE_OFN1541_acc_fft_data_in_15_ FE_OFN48_n4538
+ fifo_from_fft_fifo_cell7_sr_out[15] AO22XLTS
XU2398 n6533 FE_OFN596_n4723 FE_OFN1784_acc_fir_data_in_4_ FE_OFN584_n4724
+ fifo_from_fir_fifo_cell7_sr_out[4] AO22XLTS
XU2375 n6510 FE_OFN600_n4723 FE_OFN1652_acc_fir_data_in_27_ FE_OFN590_n4724
+ fifo_from_fir_fifo_cell7_sr_out[27] AO22XLTS
XU2400 n6535 FE_OFN596_n4723 FE_OFN1801_acc_fir_data_in_2_ FE_OFN583_n4724
+ fifo_from_fir_fifo_cell7_sr_out[2] AO22XLTS
XU2385 n6520 FE_OFN598_n4723 FE_OFN1707_acc_fir_data_in_17_ FE_OFN585_n4724
+ fifo_from_fir_fifo_cell7_sr_out[17] AO22XLTS
XU2386 n6521 FE_OFN601_n4723 FE_OFN1713_acc_fir_data_in_16_ FE_OFN585_n4724
+ fifo_from_fir_fifo_cell7_sr_out[16] AO22XLTS
XU2397 n6532 FE_OFN597_n4723 FE_OFN1778_acc_fir_data_in_5_ FE_OFN584_n4724
+ fifo_from_fir_fifo_cell7_sr_out[5] AO22XLTS
XU2378 n6513 FE_OFN602_n4723 FE_OFN1668_acc_fir_data_in_24_ FE_OFN590_n4724
+ fifo_from_fir_fifo_cell7_sr_out[24] AO22XLTS
XU1759 n5996 FE_OFN244_n4537 FE_OFN1558_acc_fft_data_in_12_ FE_OFN46_n4538
+ fifo_from_fft_fifo_cell7_sr_out[12] AO22XLTS
XU2376 n6511 FE_OFN600_n4723 FE_OFN1660_acc_fir_data_in_26_ FE_OFN590_n4724
+ fifo_from_fir_fifo_cell7_sr_out[26] AO22XLTS
XU2379 n6514 FE_OFN598_n4723 FE_OFN1675_acc_fir_data_in_23_ FE_OFN585_n4724
+ fifo_from_fir_fifo_cell7_sr_out[23] AO22XLTS
XU2402 n6537 FE_OFN594_n4723 FE_OFN1813_acc_fir_data_in_0_ FE_OFN583_n4724
+ fifo_from_fir_fifo_cell7_sr_out[0] AO22XLTS
XU2396 n6531 FE_OFN597_n4723 FE_OFN1771_acc_fir_data_in_6_ FE_OFN586_n4724
+ fifo_from_fir_fifo_cell7_sr_out[6] AO22XLTS
XU2383 n6518 FE_OFN595_n4723 FE_OFN1700_acc_fir_data_in_19_ FE_OFN582_n4724
+ fifo_from_fir_fifo_cell7_sr_out[19] AO22XLTS
XU2394 n6529 FE_OFN604_n4723 FE_OFN1756_acc_fir_data_in_8_ FE_OFN589_n4724
+ fifo_from_fir_fifo_cell7_sr_out[8] AO22XLTS
XU2381 n6516 FE_OFN598_n4723 FE_OFN1687_acc_fir_data_in_21_ FE_OFN582_n4724
+ fifo_from_fir_fifo_cell7_sr_out[21] AO22XLTS
XU2393 n6528 FE_OFN604_n4723 FE_OFN1752_acc_fir_data_in_9_ FE_OFN589_n4724
+ fifo_from_fir_fifo_cell7_sr_out[9] AO22XLTS
XU2395 n6530 FE_OFN596_n4723 FE_OFN1766_acc_fir_data_in_7_ FE_OFN584_n4724
+ fifo_from_fir_fifo_cell7_sr_out[7] AO22XLTS
XU2377 n6512 FE_OFN602_n4723 FE_OFN1663_acc_fir_data_in_25_ FE_OFN590_n4724
+ fifo_from_fir_fifo_cell7_sr_out[25] AO22XLTS
XU2392 n6527 FE_OFN603_n4723 FE_OFN1747_acc_fir_data_in_10_ FE_OFN591_n4724
+ fifo_from_fir_fifo_cell7_sr_out[10] AO22XLTS
XU2382 n6517 FE_OFN595_n4723 FE_OFN1693_acc_fir_data_in_20_ FE_OFN582_n4724
+ fifo_from_fir_fifo_cell7_sr_out[20] AO22XLTS
XU2391 n6526 FE_OFN604_n4723 FE_OFN1745_acc_fir_data_in_11_ FE_OFN589_n4724
+ fifo_from_fir_fifo_cell7_sr_out[11] AO22XLTS
XU1758 n5995 FE_OFN246_n4537 FE_OFN1551_acc_fft_data_in_13_ FE_OFN48_n4538
+ fifo_from_fft_fifo_cell7_sr_out[13] AO22XLTS
XU1742 n5979 FE_OFN253_n4537 FE_OFN1464_acc_fft_data_in_29_ FE_OFN49_n4538
+ fifo_from_fft_fifo_cell7_sr_out[29] AO22XLTS
XU1757 n5994 FE_OFN246_n4537 FE_OFN1547_acc_fft_data_in_14_ FE_OFN48_n4538
+ fifo_from_fft_fifo_cell7_sr_out[14] AO22XLTS
XU1746 n5983 FE_OFN248_n4537 FE_OFN1485_acc_fft_data_in_25_ FE_OFN44_n4538
+ fifo_from_fft_fifo_cell7_sr_out[25] AO22XLTS
XU1766 n6003 FE_OFN251_n4537 FE_OFN1594_acc_fft_data_in_5_ FE_OFN45_n4538
+ fifo_from_fft_fifo_cell7_sr_out[5] AO22XLTS
XU1763 n6000 FE_OFN255_n4537 FE_OFN1577_acc_fft_data_in_8_ FE_OFN52_n4538
+ fifo_from_fft_fifo_cell7_sr_out[8] AO22XLTS
XU904 n3872 n3907 n3873 n3973 NAND3XLTS
XU1765 n6002 FE_OFN249_n4537 FE_OFN1587_acc_fft_data_in_6_ FE_OFN50_n4538
+ fifo_from_fft_fifo_cell7_sr_out[6] AO22XLTS
XU1744 n5981 FE_OFN251_n4537 FE_OFN1476_acc_fft_data_in_27_ FE_OFN45_n4538
+ fifo_from_fft_fifo_cell7_sr_out[27] AO22XLTS
XU1769 n6006 FE_OFN248_n4537 FE_OFN1612_acc_fft_data_in_2_ FE_OFN44_n4538
+ fifo_from_fft_fifo_cell7_sr_out[2] AO22XLTS
XU1761 n5998 FE_OFN255_n4537 FE_OFN1565_acc_fft_data_in_10_ FE_OFN52_n4538
+ fifo_from_fft_fifo_cell7_sr_out[10] AO22XLTS
XU1760 n5997 FE_OFN255_n4537 FE_OFN1561_acc_fft_data_in_11_ FE_OFN52_n4538
+ fifo_from_fft_fifo_cell7_sr_out[11] AO22XLTS
XU1748 n5985 FE_OFN249_n4537 FE_OFN1497_acc_fft_data_in_23_ FE_OFN50_n4538
+ fifo_from_fft_fifo_cell7_sr_out[23] AO22XLTS
XU1768 n6005 FE_OFN252_n4537 FE_OFN1606_acc_fft_data_in_3_ FE_OFN47_n4538
+ fifo_from_fft_fifo_cell7_sr_out[3] AO22XLTS
XU1762 n5999 FE_OFN255_n4537 FE_OFN1573_acc_fft_data_in_9_ FE_OFN52_n4538
+ fifo_from_fft_fifo_cell7_sr_out[9] AO22XLTS
XU1750 n5987 FE_OFN254_n4537 FE_OFN1507_acc_fft_data_in_21_ FE_OFN51_n4538
+ fifo_from_fft_fifo_cell7_sr_out[21] AO22XLTS
XU1749 n5986 FE_OFN254_n4537 FE_OFN1500_acc_fft_data_in_22_ FE_OFN51_n4538
+ fifo_from_fft_fifo_cell7_sr_out[22] AO22XLTS
XU1770 n6007 FE_OFN251_n4537 FE_OFN1618_acc_fft_data_in_1_ FE_OFN45_n4538
+ fifo_from_fft_fifo_cell7_sr_out[1] AO22XLTS
XU1745 n5982 FE_OFN252_n4537 FE_OFN1480_acc_fft_data_in_26_ FE_OFN47_n4538
+ fifo_from_fft_fifo_cell7_sr_out[26] AO22XLTS
XU1747 n5984 FE_OFN250_n4537 FE_OFN1491_acc_fft_data_in_24_ FE_OFN44_n4538
+ fifo_from_fft_fifo_cell7_sr_out[24] AO22XLTS
XU1048 n4047 n4082 n4048 n4148 NAND3XLTS
XU1751 n5988 FE_OFN249_n4537 FE_OFN1512_acc_fft_data_in_20_ FE_OFN50_n4538
+ fifo_from_fft_fifo_cell7_sr_out[20] AO22XLTS
XU1752 n5989 n4537 FE_OFN1519_acc_fft_data_in_19_ FE_OFN43_n4538
+ fifo_from_fft_fifo_cell7_sr_out[19] AO22XLTS
XU1753 n5990 FE_OFN249_n4537 FE_OFN1523_acc_fft_data_in_18_ FE_OFN50_n4538
+ fifo_from_fft_fifo_cell7_sr_out[18] AO22XLTS
XU1767 n6004 FE_OFN245_n4537 FE_OFN1599_acc_fft_data_in_4_ FE_OFN43_n4538
+ fifo_from_fft_fifo_cell7_sr_out[4] AO22XLTS
XU1754 n5991 FE_OFN244_n4537 FE_OFN1531_acc_fft_data_in_17_ FE_OFN46_n4538
+ fifo_from_fft_fifo_cell7_sr_out[17] AO22XLTS
XU1764 n6001 FE_OFN245_n4537 FE_OFN1584_acc_fft_data_in_7_ n4538
+ fifo_from_fft_fifo_cell7_sr_out[7] AO22XLTS
XU1755 n5992 n4537 FE_OFN1536_acc_fft_data_in_16_ FE_OFN46_n4538
+ fifo_from_fft_fifo_cell7_sr_out[16] AO22XLTS
XU1771 n6008 FE_OFN252_n4537 FE_OFN1624_acc_fft_data_in_0_ FE_OFN47_n4538
+ fifo_from_fft_fifo_cell7_sr_out[0] AO22XLTS
XU1049 n4147 n8788 n4149 fifo_to_fir_hang[10] n9475 OAI211XLTS
XU905 n3972 n8809 n3974 fifo_to_fft_hang[10] n9479 OAI211XLTS
XU2369 n4719 n7564 n4722 n4717 OAI21XLTS
XU1738 n4533 n7490 n4536 FE_OFN233_n4531 OAI21XLTS
XU2368 n6505 fifo_from_fir_fifo_cell8_data_out_N35 n4721 n4719 OAI21XLTS
XU2668 n4659 n4717 n4660 n4805 NAND3XLTS
XU2343 n6481 FE_OFN577_n4717 FE_OFN1680_acc_fir_data_in_22_ FE_OFN400_n4718
+ fifo_from_fir_fifo_cell8_sr_out[22] AO22XLTS
XU2367 n6504 fifo_from_fir_fifo_cell8_controller_valid_read n4719
+ FE_OFN817_n7619 AOI21X1TS
XU2344 n6482 FE_OFN573_n4717 FE_OFN1689_acc_fir_data_in_21_ FE_OFN396_n4718
+ fifo_from_fir_fifo_cell8_sr_out[21] AO22XLTS
XU2037 n4473 n4531 n4474 n4619 NAND3XLTS
XU1713 n5953 FE_OFN239_n4531 FE_OFN1506_acc_fft_data_in_21_ FE_OFN57_n4532
+ fifo_from_fft_fifo_cell8_sr_out[21] AO22XLTS
XU1712 n5952 FE_OFN239_n4531 FE_OFN1504_acc_fft_data_in_22_ FE_OFN57_n4532
+ fifo_from_fft_fifo_cell8_sr_out[22] AO22XLTS
XU1737 n5976 fifo_from_fft_fifo_cell8_data_out_N35 n4535 n4533 OAI21XLTS
XU1736 n5975 fifo_from_fft_fifo_cell8_controller_valid_read n4533
+ FE_OFN827_n7619 AOI21X1TS
XU2334 n6472 FE_OFN581_n4717 FE_OFN1629_acc_fir_data_in_31_ FE_OFN399_n4718
+ fifo_from_fir_fifo_cell8_sr_out[31] AO22XLTS
XU2336 n6474 FE_OFN581_n4717 FE_OFN1641_acc_fir_data_in_29_ FE_OFN399_n4718
+ fifo_from_fir_fifo_cell8_sr_out[29] AO22XLTS
XU2669 n4804 n8875 n4806 fifo_from_fir_hang[7] n9467 OAI211XLTS
XU2342 n6480 FE_OFN573_n4717 FE_OFN1676_acc_fir_data_in_23_ FE_OFN396_n4718
+ fifo_from_fir_fifo_cell8_sr_out[23] AO22XLTS
XU2335 n6473 FE_OFN581_n4717 FE_OFN1634_acc_fir_data_in_30_ FE_OFN399_n4718
+ fifo_from_fir_fifo_cell8_sr_out[30] AO22XLTS
XU2345 n6483 FE_OFN571_n4717 FE_OFN1692_acc_fir_data_in_20_ n4718
+ fifo_from_fir_fifo_cell8_sr_out[20] AO22XLTS
XU2346 n6484 FE_OFN574_n4717 FE_OFN1695_acc_fir_data_in_19_ FE_OFN393_n4718
+ fifo_from_fir_fifo_cell8_sr_out[19] AO22XLTS
XU902 n3874 n7265 n3875 n3970 NAND3XLTS
XU2349 n6487 FE_OFN576_n4717 FE_OFN1716_acc_fir_data_in_16_ FE_OFN394_n4718
+ fifo_from_fir_fifo_cell8_sr_out[16] AO22XLTS
XU2347 n6485 FE_OFN576_n4717 FE_OFN1702_acc_fir_data_in_18_ FE_OFN394_n4718
+ fifo_from_fir_fifo_cell8_sr_out[18] AO22XLTS
XU1703 n5943 FE_OFN240_n4531 FE_OFN1456_acc_fft_data_in_31_ FE_OFN55_n4532
+ fifo_from_fft_fifo_cell8_sr_out[31] AO22XLTS
XU1711 n5951 FE_OFN236_n4531 FE_OFN1496_acc_fft_data_in_23_ FE_OFN53_n4532
+ fifo_from_fft_fifo_cell8_sr_out[23] AO22XLTS
XU2348 n6486 FE_OFN576_n4717 FE_OFN1707_acc_fir_data_in_17_ FE_OFN393_n4718
+ fifo_from_fir_fifo_cell8_sr_out[17] AO22XLTS
XU1704 n5944 FE_OFN240_n4531 FE_OFN1459_acc_fft_data_in_30_ FE_OFN58_n4532
+ fifo_from_fft_fifo_cell8_sr_out[30] AO22XLTS
XU1714 n5954 FE_OFN238_n4531 FE_OFN1512_acc_fft_data_in_20_ FE_OFN54_n4532
+ fifo_from_fft_fifo_cell8_sr_out[20] AO22XLTS
XU1705 n5945 FE_OFN240_n4531 FE_OFN1465_acc_fft_data_in_29_ FE_OFN58_n4532
+ fifo_from_fft_fifo_cell8_sr_out[29] AO22XLTS
XU1046 n4049 n7374 n4050 n4145 NAND3XLTS
XU2038 n4618 n8842 n4620 fifo_from_fft_hang[7] n9471 OAI211XLTS
XU2337 n6475 FE_OFN581_n4717 FE_OFN1647_acc_fir_data_in_28_ FE_OFN399_n4718
+ fifo_from_fir_fifo_cell8_sr_out[28] AO22XLTS
XU1716 n5956 FE_OFN238_n4531 FE_OFN1523_acc_fft_data_in_18_ FE_OFN54_n4532
+ fifo_from_fft_fifo_cell8_sr_out[18] AO22XLTS
XU2351 n6489 FE_OFN577_n4717 FE_OFN1728_acc_fir_data_in_14_ FE_OFN400_n4718
+ fifo_from_fir_fifo_cell8_sr_out[14] AO22XLTS
XU2365 n6503 FE_OFN574_n4717 FE_OFN1817_acc_fir_data_in_0_ FE_OFN393_n4718
+ fifo_from_fir_fifo_cell8_sr_out[0] AO22XLTS
XU2340 n6478 FE_OFN580_n4717 FE_OFN1663_acc_fir_data_in_25_ FE_OFN398_n4718
+ fifo_from_fir_fifo_cell8_sr_out[25] AO22XLTS
XU2353 n6491 FE_OFN577_n4717 FE_OFN1737_acc_fir_data_in_12_ FE_OFN400_n4718
+ fifo_from_fir_fifo_cell8_sr_out[12] AO22XLTS
XU2350 n6488 FE_OFN573_n4717 FE_OFN1721_acc_fir_data_in_15_ FE_OFN396_n4718
+ fifo_from_fir_fifo_cell8_sr_out[15] AO22XLTS
XU2355 n6493 FE_OFN577_n4717 FE_OFN1748_acc_fir_data_in_10_ FE_OFN400_n4718
+ fifo_from_fir_fifo_cell8_sr_out[10] AO22XLTS
XU1706 n5946 FE_OFN240_n4531 FE_OFN1820_acc_fft_data_in_28_ FE_OFN55_n4532
+ fifo_from_fft_fifo_cell8_sr_out[28] AO22XLTS
XU2364 n6502 FE_OFN570_n4717 FE_OFN1807_acc_fir_data_in_1_ FE_OFN391_n4718
+ fifo_from_fir_fifo_cell8_sr_out[1] AO22XLTS
XU2352 n6490 FE_OFN579_n4717 FE_OFN1731_acc_fir_data_in_13_ FE_OFN397_n4718
+ fifo_from_fir_fifo_cell8_sr_out[13] AO22XLTS
XU2363 n6501 FE_OFN572_n4717 FE_OFN1796_acc_fir_data_in_2_ FE_OFN392_n4718
+ fifo_from_fir_fifo_cell8_sr_out[2] AO22XLTS
XU2357 n6495 FE_OFN579_n4717 FE_OFN1757_acc_fir_data_in_8_ FE_OFN397_n4718
+ fifo_from_fir_fifo_cell8_sr_out[8] AO22XLTS
XU2354 n6492 FE_OFN579_n4717 FE_OFN1741_acc_fir_data_in_11_ FE_OFN397_n4718
+ fifo_from_fir_fifo_cell8_sr_out[11] AO22XLTS
XU2362 n6500 FE_OFN570_n4717 FE_OFN1791_acc_fir_data_in_3_ FE_OFN390_n4718
+ fifo_from_fir_fifo_cell8_sr_out[3] AO22XLTS
XU1715 n5955 FE_OFN243_n4531 FE_OFN1519_acc_fft_data_in_19_ FE_OFN59_n4532
+ fifo_from_fft_fifo_cell8_sr_out[19] AO22XLTS
XU1718 n5958 FE_OFN243_n4531 FE_OFN1537_acc_fft_data_in_16_ FE_OFN59_n4532
+ fifo_from_fft_fifo_cell8_sr_out[16] AO22XLTS
XU2339 n6477 FE_OFN578_n4717 FE_OFN1659_acc_fir_data_in_26_ FE_OFN398_n4718
+ fifo_from_fir_fifo_cell8_sr_out[26] AO22XLTS
XU1047 n4144 n8788 n4146 fifo_to_fir_hang[11] n9476 OAI211XLTS
XU2338 n6476 FE_OFN578_n4717 FE_OFN1652_acc_fir_data_in_27_ FE_OFN395_n4718
+ fifo_from_fir_fifo_cell8_sr_out[27] AO22XLTS
XU2356 n6494 FE_OFN579_n4717 FE_OFN1751_acc_fir_data_in_9_ FE_OFN397_n4718
+ fifo_from_fir_fifo_cell8_sr_out[9] AO22XLTS
XU2361 n6499 FE_OFN575_n4717 FE_OFN1788_acc_fir_data_in_4_ FE_OFN391_n4718
+ fifo_from_fir_fifo_cell8_sr_out[4] AO22XLTS
XU1717 n5957 FE_OFN243_n4531 FE_OFN1532_acc_fft_data_in_17_ FE_OFN59_n4532
+ fifo_from_fft_fifo_cell8_sr_out[17] AO22XLTS
XU2341 n6479 FE_OFN580_n4717 FE_OFN1667_acc_fir_data_in_24_ FE_OFN398_n4718
+ fifo_from_fir_fifo_cell8_sr_out[24] AO22XLTS
XU903 n3969 n8809 n3971 fifo_to_fft_hang[11] n9479 OAI211XLTS
XU2360 n6498 FE_OFN575_n4717 FE_OFN1782_acc_fir_data_in_5_ FE_OFN395_n4718
+ fifo_from_fir_fifo_cell8_sr_out[5] AO22XLTS
XU2358 n6496 FE_OFN572_n4717 FE_OFN1763_acc_fir_data_in_7_ FE_OFN392_n4718
+ fifo_from_fir_fifo_cell8_sr_out[7] AO22XLTS
XU2359 n6497 FE_OFN575_n4717 FE_OFN1769_acc_fir_data_in_6_ FE_OFN392_n4718
+ fifo_from_fir_fifo_cell8_sr_out[6] AO22XLTS
XU1734 n5974 FE_OFN237_n4531 FE_OFN1626_acc_fft_data_in_0_ FE_OFN58_n4532
+ fifo_from_fft_fifo_cell8_sr_out[0] AO22XLTS
XU1726 n5966 FE_OFN241_n4531 FE_OFN1577_acc_fft_data_in_8_ FE_OFN60_n4532
+ fifo_from_fft_fifo_cell8_sr_out[8] AO22XLTS
XU1728 n5968 FE_OFN235_n4531 FE_OFN1588_acc_fft_data_in_6_ FE_OFN53_n4532
+ fifo_from_fft_fifo_cell8_sr_out[6] AO22XLTS
XU1724 n5964 FE_OFN241_n4531 FE_OFN1566_acc_fft_data_in_10_ FE_OFN60_n4532
+ fifo_from_fft_fifo_cell8_sr_out[10] AO22XLTS
XU1730 n5970 FE_OFN235_n4531 FE_OFN1602_acc_fft_data_in_4_ n4532
+ fifo_from_fft_fifo_cell8_sr_out[4] AO22XLTS
XU1729 n5969 FE_OFN236_n4531 FE_OFN1594_acc_fft_data_in_5_ n4532
+ fifo_from_fft_fifo_cell8_sr_out[5] AO22XLTS
XU1731 n5971 FE_OFN237_n4531 FE_OFN1607_acc_fft_data_in_3_ FE_OFN61_n4532
+ fifo_from_fft_fifo_cell8_sr_out[3] AO22XLTS
XU1719 n5959 FE_OFN242_n4531 FE_OFN1540_acc_fft_data_in_15_ FE_OFN56_n4532
+ fifo_from_fft_fifo_cell8_sr_out[15] AO22XLTS
XU1722 n5962 FE_OFN243_n4531 FE_OFN1558_acc_fft_data_in_12_ FE_OFN59_n4532
+ fifo_from_fft_fifo_cell8_sr_out[12] AO22XLTS
XU1732 n5972 FE_OFN234_n4531 FE_OFN1614_acc_fft_data_in_2_ FE_OFN62_n4532
+ fifo_from_fft_fifo_cell8_sr_out[2] AO22XLTS
XU1727 n5967 FE_OFN235_n4531 FE_OFN1582_acc_fft_data_in_7_ n4532
+ fifo_from_fft_fifo_cell8_sr_out[7] AO22XLTS
XU1723 n5963 FE_OFN241_n4531 FE_OFN1562_acc_fft_data_in_11_ FE_OFN60_n4532
+ fifo_from_fft_fifo_cell8_sr_out[11] AO22XLTS
XU1721 n5961 FE_OFN242_n4531 FE_OFN1552_acc_fft_data_in_13_ FE_OFN56_n4532
+ fifo_from_fft_fifo_cell8_sr_out[13] AO22XLTS
XU1720 n5960 FE_OFN242_n4531 FE_OFN1547_acc_fft_data_in_14_ FE_OFN56_n4532
+ fifo_from_fft_fifo_cell8_sr_out[14] AO22XLTS
XU1725 n5965 FE_OFN241_n4531 FE_OFN1572_acc_fft_data_in_9_ FE_OFN60_n4532
+ fifo_from_fft_fifo_cell8_sr_out[9] AO22XLTS
XU1733 n5973 FE_OFN234_n4531 FE_OFN1620_acc_fft_data_in_1_ FE_OFN62_n4532
+ fifo_from_fft_fifo_cell8_sr_out[1] AO22XLTS
XU1710 n5950 FE_OFN232_n4531 FE_OFN1491_acc_fft_data_in_24_ FE_OFN62_n4532
+ fifo_from_fft_fifo_cell8_sr_out[24] AO22XLTS
XU1709 n5949 FE_OFN234_n4531 FE_OFN1487_acc_fft_data_in_25_ FE_OFN62_n4532
+ fifo_from_fft_fifo_cell8_sr_out[25] AO22XLTS
XU1707 n5947 FE_OFN237_n4531 FE_OFN1477_acc_fft_data_in_27_ FE_OFN61_n4532
+ fifo_from_fft_fifo_cell8_sr_out[27] AO22XLTS
XU1708 n5948 FE_OFN237_n4531 FE_OFN1482_acc_fft_data_in_26_ FE_OFN61_n4532
+ fifo_from_fft_fifo_cell8_sr_out[26] AO22XLTS
XU2332 n4713 n7559 n4716 n4711 OAI21XLTS
XU2666 n4661 n4711 n4662 n4802 NAND3XLTS
XU2331 n6471 fifo_from_fir_fifo_cell9_data_out_N35 n4715 n4713 OAI21XLTS
XU1701 n4527 n7485 n4530 n4525 OAI21X1TS
XU2322 n6463 FE_OFN561_n4711 FE_OFN1773_acc_fir_data_in_6_ FE_OFN427_n4712
+ fifo_from_fir_fifo_cell9_sr_out[6] AO22XLTS
XU2330 n6470 fifo_from_fir_fifo_cell9_controller_valid_read n4713
+ FE_OFN817_n7619 AOI21X1TS
XU2297 n6438 FE_OFN567_n4711 FE_OFN1628_acc_fir_data_in_31_ FE_OFN430_n4712
+ fifo_from_fir_fifo_cell9_sr_out[31] AO22XLTS
XU2667 n4801 n8875 n4803 fifo_from_fir_hang[8] n9467 OAI211XLTS
XU2327 n6468 FE_OFN560_n4711 FE_OFN1806_acc_fir_data_in_1_ n4712
+ fifo_from_fir_fifo_cell9_sr_out[1] AO22XLTS
XU2326 n6467 FE_OFN561_n4711 FE_OFN1796_acc_fir_data_in_2_ FE_OFN425_n4712
+ fifo_from_fir_fifo_cell9_sr_out[2] AO22XLTS
XU2299 n6440 FE_OFN567_n4711 FE_OFN1642_acc_fir_data_in_29_ FE_OFN430_n4712
+ fifo_from_fir_fifo_cell9_sr_out[29] AO22XLTS
XU2035 n4475 FE_OFN221_n4525 n4476 n4616 NAND3XLTS
XU2324 n6465 FE_OFN558_n4711 FE_OFN1788_acc_fir_data_in_4_ FE_OFN423_n4712
+ fifo_from_fir_fifo_cell9_sr_out[4] AO22XLTS
XU900 n3876 n7255 n3877 n3967 NAND3XLTS
XU2323 n6464 FE_OFN564_n4711 FE_OFN1782_acc_fir_data_in_5_ FE_OFN427_n4712
+ fifo_from_fir_fifo_cell9_sr_out[5] AO22XLTS
XU1700 n5942 fifo_from_fft_fifo_cell9_data_out_N35 n4529 n4527 OAI21XLTS
XU2328 n6469 FE_OFN562_n4711 FE_OFN1817_acc_fir_data_in_0_ FE_OFN423_n4712
+ fifo_from_fir_fifo_cell9_sr_out[0] AO22XLTS
XU2321 n6462 FE_OFN561_n4711 FE_OFN1767_acc_fir_data_in_7_ FE_OFN425_n4712
+ fifo_from_fir_fifo_cell9_sr_out[7] AO22XLTS
XU1044 n4051 n7365 n4052 n4142 NAND3XLTS
XU2298 n6439 FE_OFN567_n4711 FE_OFN1633_acc_fir_data_in_30_ FE_OFN430_n4712
+ fifo_from_fir_fifo_cell9_sr_out[30] AO22XLTS
XU2325 n6466 FE_OFN559_n4711 FE_OFN1791_acc_fir_data_in_3_ FE_OFN423_n4712
+ fifo_from_fir_fifo_cell9_sr_out[3] AO22XLTS
XU1699 n5941 fifo_from_fft_fifo_cell9_controller_valid_read n4527
+ FE_OFN830_n7619 AOI21X1TS
XU1675 n5918 FE_OFN227_n4525 FE_OFN1500_acc_fft_data_in_22_ FE_OFN91_n4526
+ fifo_from_fft_fifo_cell9_sr_out[22] AO22XLTS
XU1677 n5920 FE_OFN230_n4525 FE_OFN1510_acc_fft_data_in_20_ FE_OFN93_n4526
+ fifo_from_fft_fifo_cell9_sr_out[20] AO22XLTS
XU1676 n5919 FE_OFN227_n4525 FE_OFN1505_acc_fft_data_in_21_ FE_OFN91_n4526
+ fifo_from_fft_fifo_cell9_sr_out[21] AO22XLTS
XU1674 n5917 FE_OFN225_n4525 FE_OFN1497_acc_fft_data_in_23_ FE_OFN87_n4526
+ fifo_from_fft_fifo_cell9_sr_out[23] AO22XLTS
XU2036 n4615 n8842 n4617 fifo_from_fft_hang[8] n9471 OAI211XLTS
XU901 n3966 n8809 n3968 fifo_to_fft_hang[12] n9478 OAI211XLTS
XU2300 n6441 FE_OFN567_n4711 FE_OFN1647_acc_fir_data_in_28_ FE_OFN430_n4712
+ fifo_from_fir_fifo_cell9_sr_out[28] AO22XLTS
XU1045 n4141 n8788 n4143 fifo_to_fir_hang[12] n9474 OAI211XLTS
XU1669 n5912 FE_OFN228_n4525 FE_OFN1470_acc_fft_data_in_28_ FE_OFN87_n4526
+ fifo_from_fft_fifo_cell9_sr_out[28] AO22XLTS
XU1668 n5911 FE_OFN228_n4525 FE_OFN1463_acc_fft_data_in_29_ FE_OFN90_n4526
+ fifo_from_fft_fifo_cell9_sr_out[29] AO22XLTS
XU1667 n5910 FE_OFN228_n4525 FE_OFN1458_acc_fft_data_in_30_ FE_OFN90_n4526
+ fifo_from_fft_fifo_cell9_sr_out[30] AO22XLTS
XU1666 n5909 FE_OFN228_n4525 FE_OFN1457_acc_fft_data_in_31_ FE_OFN90_n4526
+ fifo_from_fft_fifo_cell9_sr_out[31] AO22XLTS
XU2311 n6452 FE_OFN562_n4711 FE_OFN1709_acc_fir_data_in_17_ FE_OFN426_n4712
+ fifo_from_fir_fifo_cell9_sr_out[17] AO22XLTS
XU2310 n6451 FE_OFN563_n4711 FE_OFN1703_acc_fir_data_in_18_ FE_OFN426_n4712
+ fifo_from_fir_fifo_cell9_sr_out[18] AO22XLTS
XU1687 n5930 FE_OFN229_n4525 FE_OFN1564_acc_fft_data_in_10_ FE_OFN91_n4526
+ fifo_from_fft_fifo_cell9_sr_out[10] AO22XLTS
XU1678 n5921 FE_OFN226_n4525 FE_OFN1519_acc_fft_data_in_19_ FE_OFN85_n4526
+ fifo_from_fft_fifo_cell9_sr_out[19] AO22XLTS
XU2314 n6455 FE_OFN569_n4711 FE_OFN1727_acc_fir_data_in_14_ FE_OFN432_n4712
+ fifo_from_fir_fifo_cell9_sr_out[14] AO22XLTS
XU2309 n6450 FE_OFN562_n4711 FE_OFN1699_acc_fir_data_in_19_ FE_OFN424_n4712
+ fifo_from_fir_fifo_cell9_sr_out[19] AO22XLTS
XU1689 n5932 FE_OFN230_n4525 FE_OFN1574_acc_fft_data_in_8_ FE_OFN92_n4526
+ fifo_from_fft_fifo_cell9_sr_out[8] AO22XLTS
XU1685 n5928 FE_OFN231_n4525 FE_OFN1555_acc_fft_data_in_12_ FE_OFN94_n4526
+ fifo_from_fft_fifo_cell9_sr_out[12] AO22XLTS
XU1679 n5922 FE_OFN226_n4525 FE_OFN1525_acc_fft_data_in_18_ FE_OFN85_n4526
+ fifo_from_fft_fifo_cell9_sr_out[18] AO22XLTS
XU2315 n6456 FE_OFN565_n4711 FE_OFN1733_acc_fir_data_in_13_ FE_OFN428_n4712
+ fifo_from_fir_fifo_cell9_sr_out[13] AO22XLTS
XU1686 n5929 FE_OFN229_n4525 FE_OFN1559_acc_fft_data_in_11_ FE_OFN92_n4526
+ fifo_from_fft_fifo_cell9_sr_out[11] AO22XLTS
XU2313 n6454 FE_OFN566_n4711 FE_OFN1721_acc_fir_data_in_15_ FE_OFN429_n4712
+ fifo_from_fir_fifo_cell9_sr_out[15] AO22XLTS
XU2320 n6461 FE_OFN566_n4711 FE_OFN1760_acc_fir_data_in_8_ FE_OFN429_n4712
+ fifo_from_fir_fifo_cell9_sr_out[8] AO22XLTS
XU2319 n6460 FE_OFN565_n4711 FE_OFN1752_acc_fir_data_in_9_ FE_OFN428_n4712
+ fifo_from_fir_fifo_cell9_sr_out[9] AO22XLTS
XU1690 n5933 FE_OFN223_n4525 FE_OFN1582_acc_fft_data_in_7_ FE_OFN86_n4526
+ fifo_from_fft_fifo_cell9_sr_out[7] AO22XLTS
XU2307 n6448 FE_OFN569_n4711 FE_OFN1685_acc_fir_data_in_21_ FE_OFN432_n4712
+ fifo_from_fir_fifo_cell9_sr_out[21] AO22XLTS
XU2317 n6458 FE_OFN565_n4711 FE_OFN1742_acc_fir_data_in_11_ FE_OFN428_n4712
+ fifo_from_fir_fifo_cell9_sr_out[11] AO22XLTS
XU1684 n5927 FE_OFN230_n4525 FE_OFN1549_acc_fft_data_in_13_ FE_OFN93_n4526
+ fifo_from_fft_fifo_cell9_sr_out[13] AO22XLTS
XU2312 n6453 FE_OFN563_n4711 FE_OFN1713_acc_fir_data_in_16_ FE_OFN426_n4712
+ fifo_from_fir_fifo_cell9_sr_out[16] AO22XLTS
XU1683 n5926 FE_OFN231_n4525 FE_OFN1546_acc_fft_data_in_14_ FE_OFN94_n4526
+ fifo_from_fft_fifo_cell9_sr_out[14] AO22XLTS
XU2308 n6449 FE_OFN560_n4711 FE_OFN1692_acc_fir_data_in_20_ n4712
+ fifo_from_fir_fifo_cell9_sr_out[20] AO22XLTS
XU2316 n6457 FE_OFN569_n4711 FE_OFN1736_acc_fir_data_in_12_ FE_OFN432_n4712
+ fifo_from_fir_fifo_cell9_sr_out[12] AO22XLTS
XU1691 n5934 FE_OFN225_n4525 FE_OFN1588_acc_fft_data_in_6_ FE_OFN87_n4526
+ fifo_from_fft_fifo_cell9_sr_out[6] AO22XLTS
XU2318 n6459 FE_OFN566_n4711 FE_OFN1748_acc_fir_data_in_10_ FE_OFN429_n4712
+ fifo_from_fir_fifo_cell9_sr_out[10] AO22XLTS
XU2306 n6447 FE_OFN569_n4711 FE_OFN1678_acc_fir_data_in_22_ FE_OFN432_n4712
+ fifo_from_fir_fifo_cell9_sr_out[22] AO22XLTS
XU1682 n5925 FE_OFN231_n4525 FE_OFN1539_acc_fft_data_in_15_ FE_OFN94_n4526
+ fifo_from_fft_fifo_cell9_sr_out[15] AO22XLTS
XU1692 n5935 FE_OFN225_n4525 FE_OFN1593_acc_fft_data_in_5_ FE_OFN84_n4526
+ fifo_from_fft_fifo_cell9_sr_out[5] AO22XLTS
XU2305 n6446 FE_OFN563_n4711 FE_OFN1671_acc_fir_data_in_23_ FE_OFN424_n4712
+ fifo_from_fir_fifo_cell9_sr_out[23] AO22XLTS
XU2303 n6444 FE_OFN568_n4711 FE_OFN1661_acc_fir_data_in_25_ FE_OFN431_n4712
+ fifo_from_fir_fifo_cell9_sr_out[25] AO22XLTS
XU1681 n5924 FE_OFN226_n4525 FE_OFN1537_acc_fft_data_in_16_ FE_OFN85_n4526
+ fifo_from_fft_fifo_cell9_sr_out[16] AO22XLTS
XU2302 n6443 FE_OFN568_n4711 FE_OFN1656_acc_fir_data_in_26_ FE_OFN431_n4712
+ fifo_from_fir_fifo_cell9_sr_out[26] AO22XLTS
XU1693 n5936 FE_OFN226_n4525 FE_OFN1601_acc_fft_data_in_4_ FE_OFN84_n4526
+ fifo_from_fft_fifo_cell9_sr_out[4] AO22XLTS
XU1680 n5923 FE_OFN231_n4525 FE_OFN1529_acc_fft_data_in_17_ FE_OFN94_n4526
+ fifo_from_fft_fifo_cell9_sr_out[17] AO22XLTS
XU1670 n5913 FE_OFN224_n4525 FE_OFN1476_acc_fft_data_in_27_ FE_OFN89_n4526
+ fifo_from_fft_fifo_cell9_sr_out[27] AO22XLTS
XU1694 n5937 FE_OFN224_n4525 FE_OFN1607_acc_fft_data_in_3_ FE_OFN89_n4526
+ fifo_from_fft_fifo_cell9_sr_out[3] AO22XLTS
XU1695 n5938 FE_OFN222_n4525 FE_OFN1614_acc_fft_data_in_2_ FE_OFN88_n4526
+ fifo_from_fft_fifo_cell9_sr_out[2] AO22XLTS
XU2304 n6445 FE_OFN568_n4711 FE_OFN1666_acc_fir_data_in_24_ FE_OFN431_n4712
+ fifo_from_fir_fifo_cell9_sr_out[24] AO22XLTS
XU1673 n5916 FE_OFN221_n4525 FE_OFN1492_acc_fft_data_in_24_ FE_OFN88_n4526
+ fifo_from_fft_fifo_cell9_sr_out[24] AO22XLTS
XU1671 n5914 FE_OFN224_n4525 FE_OFN1481_acc_fft_data_in_26_ FE_OFN89_n4526
+ fifo_from_fft_fifo_cell9_sr_out[26] AO22XLTS
XU1696 n5939 FE_OFN222_n4525 FE_OFN1621_acc_fft_data_in_1_ FE_OFN86_n4526
+ fifo_from_fft_fifo_cell9_sr_out[1] AO22XLTS
XU1697 n5940 FE_OFN224_n4525 FE_OFN1625_acc_fft_data_in_0_ FE_OFN89_n4526
+ fifo_from_fft_fifo_cell9_sr_out[0] AO22XLTS
XU1688 n5931 FE_OFN229_n4525 FE_OFN1569_acc_fft_data_in_9_ FE_OFN92_n4526
+ fifo_from_fft_fifo_cell9_sr_out[9] AO22XLTS
XU2301 n6442 FE_OFN564_n4711 FE_OFN1653_acc_fir_data_in_27_ FE_OFN431_n4712
+ fifo_from_fir_fifo_cell9_sr_out[27] AO22XLTS
XU1672 n5915 FE_OFN221_n4525 FE_OFN1485_acc_fft_data_in_25_ FE_OFN88_n4526
+ fifo_from_fft_fifo_cell9_sr_out[25] AO22XLTS
XU2295 n4707 n7554 n4710 FE_OFN546_n4705 OAI21XLTS
XU1042 n4053 n4067 n4054 n4139 NAND3XLTS
XU898 n3878 n3892 n3879 n3964 NAND3XLTS
XU1664 n4521 n7480 n4524 FE_OFN209_n4519 OAI21XLTS
XU2269 n6413 FE_OFN554_n4705 FE_OFN1681_acc_fir_data_in_22_ FE_OFN439_n4706
+ fifo_from_fir_fifo_cell10_sr_out[22] AO22XLTS
XU2664 n4663 FE_OFN546_n4705 n4664 n4799 NAND3XLTS
XU2293 n6436 fifo_from_fir_fifo_cell10_controller_valid_read n4707
+ FE_OFN803_n7619 AOI21X1TS
XU1043 n4138 n8787 n4140 fifo_to_fir_hang[13] n9476 OAI211XLTS
XU899 n3963 n8808 n3965 fifo_to_fft_hang[13] n9480 OAI211XLTS
XU2294 n6437 fifo_from_fir_fifo_cell10_data_out_N35 n4709 n4707 OAI21XLTS
XU2270 n6414 FE_OFN550_n4705 FE_OFN1687_acc_fir_data_in_21_ FE_OFN436_n4706
+ fifo_from_fir_fifo_cell10_sr_out[21] AO22XLTS
XU3327 n4056 n4062 INVX1TS
XU2033 n4477 n4519 n4478 n4613 NAND3XLTS
XU2262 n6406 FE_OFN557_n4705 FE_OFN1645_acc_fir_data_in_29_ FE_OFN442_n4706
+ fifo_from_fir_fifo_cell10_sr_out[29] AO22XLTS
XU1638 n5884 FE_OFN219_n4519 FE_OFN1501_acc_fft_data_in_22_ FE_OFN103_n4520
+ fifo_from_fft_fifo_cell10_sr_out[22] AO22XLTS
XU1663 n5908 fifo_from_fft_fifo_cell10_data_out_N35 n4523 n4521 OAI21XLTS
XU3470 n3881 n3887 INVX1TS
XU2665 n4798 n8875 n4800 fifo_from_fir_hang[9] n9468 OAI211XLTS
XU2261 n6405 FE_OFN557_n4705 FE_OFN1637_acc_fir_data_in_30_ FE_OFN442_n4706
+ fifo_from_fir_fifo_cell10_sr_out[30] AO22XLTS
XU2271 n6415 FE_OFN549_n4705 FE_OFN1690_acc_fir_data_in_20_ FE_OFN433_n4706
+ fifo_from_fir_fifo_cell10_sr_out[20] AO22XLTS
XU2268 n6412 FE_OFN550_n4705 FE_OFN1676_acc_fir_data_in_23_ FE_OFN436_n4706
+ fifo_from_fir_fifo_cell10_sr_out[23] AO22XLTS
XU1639 n5885 FE_OFN219_n4519 FE_OFN1507_acc_fft_data_in_21_ FE_OFN103_n4520
+ fifo_from_fft_fifo_cell10_sr_out[21] AO22XLTS
XU2260 n6404 FE_OFN557_n4705 FE_OFN1632_acc_fir_data_in_31_ FE_OFN442_n4706
+ fifo_from_fir_fifo_cell10_sr_out[31] AO22XLTS
XU1662 n5907 fifo_from_fft_fifo_cell10_controller_valid_read n4521
+ FE_OFN820_n7619 AOI21X1TS
XU1631 n5877 FE_OFN216_n4519 FE_OFN1464_acc_fft_data_in_29_ FE_OFN102_n4520
+ fifo_from_fft_fifo_cell10_sr_out[29] AO22XLTS
XU2263 n6407 FE_OFN557_n4705 FE_OFN1650_acc_fir_data_in_28_ FE_OFN442_n4706
+ fifo_from_fir_fifo_cell10_sr_out[28] AO22XLTS
XU1637 n5883 FE_OFN213_n4519 FE_OFN1496_acc_fft_data_in_23_ FE_OFN97_n4520
+ fifo_from_fft_fifo_cell10_sr_out[23] AO22XLTS
XU1630 n5876 FE_OFN216_n4519 FE_OFN1461_acc_fft_data_in_30_ FE_OFN102_n4520
+ fifo_from_fft_fifo_cell10_sr_out[30] AO22XLTS
XU1629 n5875 FE_OFN216_n4519 FE_OFN1455_acc_fft_data_in_31_ FE_OFN102_n4520
+ fifo_from_fft_fifo_cell10_sr_out[31] AO22XLTS
XU2274 n6418 FE_OFN551_n4705 FE_OFN1711_acc_fir_data_in_17_ FE_OFN435_n4706
+ fifo_from_fir_fifo_cell10_sr_out[17] AO22XLTS
XU1640 n5886 FE_OFN218_n4519 FE_OFN1511_acc_fft_data_in_20_ FE_OFN101_n4520
+ fifo_from_fft_fifo_cell10_sr_out[20] AO22XLTS
XU2273 n6417 FE_OFN551_n4705 FE_OFN1703_acc_fir_data_in_18_ FE_OFN435_n4706
+ fifo_from_fir_fifo_cell10_sr_out[18] AO22XLTS
XU2034 n4612 n8842 n4614 fifo_from_fft_hang[9] n9471 OAI211XLTS
XU2275 n6419 FE_OFN551_n4705 FE_OFN1712_acc_fir_data_in_16_ FE_OFN435_n4706
+ fifo_from_fir_fifo_cell10_sr_out[16] AO22XLTS
XU2272 n6416 FE_OFN549_n4705 FE_OFN1701_acc_fir_data_in_19_ FE_OFN433_n4706
+ fifo_from_fir_fifo_cell10_sr_out[19] AO22XLTS
XU2280 n6424 FE_OFN556_n4705 FE_OFN1745_acc_fir_data_in_11_ FE_OFN440_n4706
+ fifo_from_fir_fifo_cell10_sr_out[11] AO22XLTS
XU1641 n5887 FE_OFN215_n4519 FE_OFN1519_acc_fft_data_in_19_ FE_OFN98_n4520
+ fifo_from_fft_fifo_cell10_sr_out[19] AO22XLTS
XU1632 n5878 FE_OFN219_n4519 FE_OFN1472_acc_fft_data_in_28_ FE_OFN103_n4520
+ fifo_from_fft_fifo_cell10_sr_out[28] AO22XLTS
XU2277 n6421 FE_OFN550_n4705 FE_OFN1728_acc_fir_data_in_14_ FE_OFN436_n4706
+ fifo_from_fir_fifo_cell10_sr_out[14] AO22XLTS
XU2283 n6427 FE_OFN556_n4705 FE_OFN1757_acc_fir_data_in_8_ FE_OFN440_n4706
+ fifo_from_fir_fifo_cell10_sr_out[8] AO22XLTS
XU2284 n6428 FE_OFN553_n4705 FE_OFN1763_acc_fir_data_in_7_ FE_OFN437_n4706
+ fifo_from_fir_fifo_cell10_sr_out[7] AO22XLTS
XU2286 n6430 FE_OFN552_n4705 FE_OFN1782_acc_fir_data_in_5_ FE_OFN438_n4706
+ fifo_from_fir_fifo_cell10_sr_out[5] AO22XLTS
XU2291 n6435 FE_OFN553_n4705 FE_OFN1810_acc_fir_data_in_0_ FE_OFN437_n4706
+ fifo_from_fir_fifo_cell10_sr_out[0] AO22XLTS
XU1644 n5890 FE_OFN217_n4519 FE_OFN1536_acc_fft_data_in_16_ FE_OFN100_n4520
+ fifo_from_fft_fifo_cell10_sr_out[16] AO22XLTS
XU2285 n6429 FE_OFN548_n4705 FE_OFN1770_acc_fir_data_in_6_ FE_OFN434_n4706
+ fifo_from_fir_fifo_cell10_sr_out[6] AO22XLTS
XU2266 n6410 FE_OFN555_n4705 FE_OFN1665_acc_fir_data_in_25_ FE_OFN441_n4706
+ fifo_from_fir_fifo_cell10_sr_out[25] AO22XLTS
XU2290 n6434 n4705 FE_OFN1807_acc_fir_data_in_1_ n4706
+ fifo_from_fir_fifo_cell10_sr_out[1] AO22XLTS
XU2288 n6432 FE_OFN547_n4705 FE_OFN1794_acc_fir_data_in_3_ n4706
+ fifo_from_fir_fifo_cell10_sr_out[3] AO22XLTS
XU2287 n6431 FE_OFN548_n4705 FE_OFN1788_acc_fir_data_in_4_ FE_OFN434_n4706
+ fifo_from_fir_fifo_cell10_sr_out[4] AO22XLTS
XU1643 n5889 FE_OFN217_n4519 FE_OFN1531_acc_fft_data_in_17_ FE_OFN100_n4520
+ fifo_from_fft_fifo_cell10_sr_out[17] AO22XLTS
XU2289 n6433 FE_OFN553_n4705 FE_OFN1795_acc_fir_data_in_2_ FE_OFN437_n4706
+ fifo_from_fir_fifo_cell10_sr_out[2] AO22XLTS
XU2279 n6423 FE_OFN554_n4705 FE_OFN1736_acc_fir_data_in_12_ FE_OFN439_n4706
+ fifo_from_fir_fifo_cell10_sr_out[12] AO22XLTS
XU2278 n6422 FE_OFN556_n4705 FE_OFN1731_acc_fir_data_in_13_ FE_OFN440_n4706
+ fifo_from_fir_fifo_cell10_sr_out[13] AO22XLTS
XU2265 n6409 FE_OFN555_n4705 FE_OFN1658_acc_fir_data_in_26_ FE_OFN441_n4706
+ fifo_from_fir_fifo_cell10_sr_out[26] AO22XLTS
XU2267 n6411 FE_OFN555_n4705 FE_OFN1670_acc_fir_data_in_24_ FE_OFN441_n4706
+ fifo_from_fir_fifo_cell10_sr_out[24] AO22XLTS
XU1642 n5888 FE_OFN218_n4519 FE_OFN1522_acc_fft_data_in_18_ FE_OFN101_n4520
+ fifo_from_fft_fifo_cell10_sr_out[18] AO22XLTS
XU2282 n6426 FE_OFN556_n4705 FE_OFN1751_acc_fir_data_in_9_ FE_OFN440_n4706
+ fifo_from_fir_fifo_cell10_sr_out[9] AO22XLTS
XU2264 n6408 FE_OFN552_n4705 FE_OFN1655_acc_fir_data_in_27_ FE_OFN438_n4706
+ fifo_from_fir_fifo_cell10_sr_out[27] AO22XLTS
XU2276 n6420 FE_OFN554_n4705 FE_OFN1719_acc_fir_data_in_15_ FE_OFN439_n4706
+ fifo_from_fir_fifo_cell10_sr_out[15] AO22XLTS
XU2281 n6425 FE_OFN554_n4705 FE_OFN1746_acc_fir_data_in_10_ FE_OFN439_n4706
+ fifo_from_fir_fifo_cell10_sr_out[10] AO22XLTS
XU1649 n5895 FE_OFN220_n4519 FE_OFN1561_acc_fft_data_in_11_ FE_OFN104_n4520
+ fifo_from_fft_fifo_cell10_sr_out[11] AO22XLTS
XU1646 n5892 FE_OFN215_n4519 FE_OFN1547_acc_fft_data_in_14_ FE_OFN98_n4520
+ fifo_from_fft_fifo_cell10_sr_out[14] AO22XLTS
XU1635 n5881 FE_OFN210_n4519 FE_OFN1487_acc_fft_data_in_25_ n4520
+ fifo_from_fft_fifo_cell10_sr_out[25] AO22XLTS
XU1647 n5893 FE_OFN218_n4519 FE_OFN1552_acc_fft_data_in_13_ FE_OFN101_n4520
+ fifo_from_fft_fifo_cell10_sr_out[13] AO22XLTS
XU1653 n5899 FE_OFN212_n4519 FE_OFN1583_acc_fft_data_in_7_ FE_OFN97_n4520
+ fifo_from_fft_fifo_cell10_sr_out[7] AO22XLTS
XU2258 n4701 n7549 n4704 FE_OFN534_n4699 OAI21XLTS
XU1659 n5905 FE_OFN211_n4519 FE_OFN1620_acc_fft_data_in_1_ FE_OFN96_n4520
+ fifo_from_fft_fifo_cell10_sr_out[1] AO22XLTS
XU1633 n5879 FE_OFN211_n4519 FE_OFN1477_acc_fft_data_in_27_ FE_OFN96_n4520
+ fifo_from_fft_fifo_cell10_sr_out[27] AO22XLTS
XU1645 n5891 FE_OFN218_n4519 FE_OFN1541_acc_fft_data_in_15_ FE_OFN101_n4520
+ fifo_from_fft_fifo_cell10_sr_out[15] AO22XLTS
XU1660 n5906 FE_OFN214_n4519 FE_OFN1625_acc_fft_data_in_0_ FE_OFN99_n4520
+ fifo_from_fft_fifo_cell10_sr_out[0] AO22XLTS
XU897 n3962 n8810 n3880 fifo_to_fft_hang[14] n9480 OAI211XLTS
XU1648 n5894 FE_OFN217_n4519 FE_OFN1558_acc_fft_data_in_12_ FE_OFN100_n4520
+ fifo_from_fft_fifo_cell10_sr_out[12] AO22XLTS
XU1651 n5897 FE_OFN220_n4519 FE_OFN1573_acc_fft_data_in_9_ FE_OFN104_n4520
+ fifo_from_fft_fifo_cell10_sr_out[9] AO22XLTS
XU1650 n5896 FE_OFN220_n4519 FE_OFN1568_acc_fft_data_in_10_ FE_OFN104_n4520
+ fifo_from_fft_fifo_cell10_sr_out[10] AO22XLTS
XU1634 n5880 FE_OFN214_n4519 FE_OFN1482_acc_fft_data_in_26_ FE_OFN99_n4520
+ fifo_from_fft_fifo_cell10_sr_out[26] AO22XLTS
XU1656 n5902 FE_OFN213_n4519 FE_OFN1599_acc_fft_data_in_4_ FE_OFN95_n4520
+ fifo_from_fft_fifo_cell10_sr_out[4] AO22XLTS
XU1654 n5900 FE_OFN213_n4519 FE_OFN1587_acc_fft_data_in_6_ FE_OFN97_n4520
+ fifo_from_fft_fifo_cell10_sr_out[6] AO22XLTS
XU1636 n5882 n4519 FE_OFN1491_acc_fft_data_in_24_ n4520
+ fifo_from_fft_fifo_cell10_sr_out[24] AO22XLTS
XU1652 n5898 FE_OFN220_n4519 FE_OFN1578_acc_fft_data_in_8_ FE_OFN104_n4520
+ fifo_from_fft_fifo_cell10_sr_out[8] AO22XLTS
XU1657 n5903 FE_OFN214_n4519 FE_OFN1607_acc_fft_data_in_3_ FE_OFN99_n4520
+ fifo_from_fft_fifo_cell10_sr_out[3] AO22XLTS
XU1658 n5904 FE_OFN211_n4519 FE_OFN1614_acc_fft_data_in_2_ FE_OFN96_n4520
+ fifo_from_fft_fifo_cell10_sr_out[2] AO22XLTS
XU1655 n5901 FE_OFN212_n4519 FE_OFN1593_acc_fft_data_in_5_ FE_OFN97_n4520
+ fifo_from_fft_fifo_cell10_sr_out[5] AO22XLTS
XU2256 n6402 fifo_from_fir_fifo_cell11_controller_valid_read n4701
+ FE_OFN808_n7619 AOI21X1TS
XU2662 n4665 FE_OFN534_n4699 n4666 n4796 NAND3XLTS
XU1627 n4515 n7475 n4518 FE_OFN199_n4513 OAI21XLTS
XU896 n5516 fifo_to_fft_hang[14] n3881 n3880 n3962 OAI31XLTS
XU1040 n5568 fifo_to_fir_hang[14] n4056 n4055 n4137 OAI31XLTS
XU2257 n6403 fifo_from_fir_fifo_cell11_data_out_N35 n4703 n4701 OAI21XLTS
XU2242 n6389 FE_OFN544_n4699 FE_OFN1739_acc_fir_data_in_12_ FE_OFN532_n4700
+ fifo_from_fir_fifo_cell11_sr_out[12] AO22XLTS
XU2663 n4795 n8874 n4797 fifo_from_fir_hang[10] n9468 OAI211XLTS
XU2223 n6370 FE_OFN545_n4699 FE_OFN1629_acc_fir_data_in_31_ FE_OFN533_n4700
+ fifo_from_fir_fifo_cell11_sr_out[31] AO22XLTS
XU1625 n5873 fifo_from_fft_fifo_cell11_controller_valid_read n4515
+ FE_OFN820_n7619 AOI21X1TS
XU2240 n6387 FE_OFN544_n4699 FE_OFN1730_acc_fir_data_in_14_ FE_OFN532_n4700
+ fifo_from_fir_fifo_cell11_sr_out[14] AO22XLTS
XU2031 n4479 FE_OFN199_n4513 n4480 n4610 NAND3XLTS
XU2226 n6373 FE_OFN545_n4699 FE_OFN1649_acc_fir_data_in_28_ FE_OFN533_n4700
+ fifo_from_fir_fifo_cell11_sr_out[28] AO22XLTS
XU1626 n5874 fifo_from_fft_fifo_cell11_data_out_N35 n4517 n4515 OAI21XLTS
XU2225 n6372 FE_OFN545_n4699 FE_OFN1644_acc_fir_data_in_29_ FE_OFN533_n4700
+ fifo_from_fir_fifo_cell11_sr_out[29] AO22XLTS
XU2224 n6371 FE_OFN545_n4699 FE_OFN1636_acc_fir_data_in_30_ FE_OFN533_n4700
+ fifo_from_fir_fifo_cell11_sr_out[30] AO22XLTS
XU2241 n6388 FE_OFN539_n4699 FE_OFN1733_acc_fir_data_in_13_ FE_OFN528_n4700
+ fifo_from_fir_fifo_cell11_sr_out[13] AO22XLTS
XU2239 n6386 FE_OFN544_n4699 FE_OFN1723_acc_fir_data_in_15_ FE_OFN532_n4700
+ fifo_from_fir_fifo_cell11_sr_out[15] AO22XLTS
XU1595 n5844 FE_OFN207_n4513 FE_OFN1472_acc_fft_data_in_28_ FE_OFN195_n4514
+ fifo_from_fft_fifo_cell11_sr_out[28] AO22XLTS
XU1593 n5842 FE_OFN204_n4513 FE_OFN1461_acc_fft_data_in_30_ FE_OFN192_n4514
+ fifo_from_fft_fifo_cell11_sr_out[30] AO22XLTS
XU2234 n6381 FE_OFN538_n4699 FE_OFN1693_acc_fir_data_in_20_ FE_OFN525_n4700
+ fifo_from_fir_fifo_cell11_sr_out[20] AO22XLTS
XU2252 n6399 FE_OFN537_n4699 FE_OFN1800_acc_fir_data_in_2_ FE_OFN524_n4700
+ fifo_from_fir_fifo_cell11_sr_out[2] AO22XLTS
XU778 n5454 fifo_to_fir_fifo_cell0_controller_valid_read n3808 FE_OFN798_n7619
+ AOI21X1TS
XU2237 n6384 FE_OFN536_n4699 FE_OFN1709_acc_fir_data_in_17_ FE_OFN523_n4700
+ fifo_from_fir_fifo_cell11_sr_out[17] AO22XLTS
XU2250 n6397 FE_OFN537_n4699 FE_OFN1786_acc_fir_data_in_4_ FE_OFN526_n4700
+ fifo_from_fir_fifo_cell11_sr_out[4] AO22XLTS
XU2238 n6385 FE_OFN536_n4699 FE_OFN1718_acc_fir_data_in_16_ FE_OFN527_n4700
+ fifo_from_fir_fifo_cell11_sr_out[16] AO22XLTS
XU2249 n6396 FE_OFN540_n4699 FE_OFN1781_acc_fir_data_in_5_ FE_OFN529_n4700
+ fifo_from_fir_fifo_cell11_sr_out[5] AO22XLTS
XU2246 n6393 FE_OFN542_n4699 FE_OFN1761_acc_fir_data_in_8_ FE_OFN530_n4700
+ fifo_from_fir_fifo_cell11_sr_out[8] AO22XLTS
XU2227 n6374 FE_OFN541_n4699 FE_OFN1654_acc_fir_data_in_27_ FE_OFN531_n4700
+ fifo_from_fir_fifo_cell11_sr_out[27] AO22XLTS
XU2228 n6375 FE_OFN541_n4699 FE_OFN1660_acc_fir_data_in_26_ FE_OFN531_n4700
+ fifo_from_fir_fifo_cell11_sr_out[26] AO22XLTS
XU2229 n6376 FE_OFN543_n4699 FE_OFN1663_acc_fir_data_in_25_ FE_OFN529_n4700
+ fifo_from_fir_fifo_cell11_sr_out[25] AO22XLTS
XU2253 n6400 n4699 FE_OFN1807_acc_fir_data_in_1_ n4700
+ fifo_from_fir_fifo_cell11_sr_out[1] AO22XLTS
XU2230 n6377 FE_OFN543_n4699 FE_OFN1668_acc_fir_data_in_24_ FE_OFN529_n4700
+ fifo_from_fir_fifo_cell11_sr_out[24] AO22XLTS
XU2254 n6401 FE_OFN537_n4699 FE_OFN1811_acc_fir_data_in_0_ FE_OFN524_n4700
+ fifo_from_fir_fifo_cell11_sr_out[0] AO22XLTS
XU2245 n6392 FE_OFN542_n4699 FE_OFN1754_acc_fir_data_in_9_ FE_OFN530_n4700
+ fifo_from_fir_fifo_cell11_sr_out[9] AO22XLTS
XU2231 n6378 FE_OFN538_n4699 FE_OFN1673_acc_fir_data_in_23_ FE_OFN525_n4700
+ fifo_from_fir_fifo_cell11_sr_out[23] AO22XLTS
XU2032 n4609 n8841 n4611 fifo_from_fft_hang[10] n9472 OAI211XLTS
XU2232 n6379 FE_OFN544_n4699 FE_OFN1681_acc_fir_data_in_22_ FE_OFN532_n4700
+ fifo_from_fir_fifo_cell11_sr_out[22] AO22XLTS
XU2251 n6398 FE_OFN535_n4699 FE_OFN1790_acc_fir_data_in_3_ FE_OFN524_n4700
+ fifo_from_fir_fifo_cell11_sr_out[3] AO22XLTS
XU2247 n6394 FE_OFN540_n4699 FE_OFN1765_acc_fir_data_in_7_ FE_OFN526_n4700
+ fifo_from_fir_fifo_cell11_sr_out[7] AO22XLTS
XU1610 n5859 FE_OFN206_n4513 FE_OFN1551_acc_fft_data_in_13_ FE_OFN194_n4514
+ fifo_from_fft_fifo_cell11_sr_out[13] AO22XLTS
XU2233 n6380 FE_OFN538_n4699 FE_OFN1689_acc_fir_data_in_21_ FE_OFN527_n4700
+ fifo_from_fir_fifo_cell11_sr_out[21] AO22XLTS
XU1592 n5841 FE_OFN204_n4513 FE_OFN1457_acc_fft_data_in_31_ FE_OFN192_n4514
+ fifo_from_fft_fifo_cell11_sr_out[31] AO22XLTS
XU2243 n6390 FE_OFN539_n4699 FE_OFN1744_acc_fir_data_in_11_ FE_OFN528_n4700
+ fifo_from_fir_fifo_cell11_sr_out[11] AO22XLTS
XU2236 n6383 FE_OFN539_n4699 FE_OFN1705_acc_fir_data_in_18_ FE_OFN527_n4700
+ fifo_from_fir_fifo_cell11_sr_out[18] AO22XLTS
XU2248 n6395 FE_OFN540_n4699 FE_OFN1776_acc_fir_data_in_6_ FE_OFN526_n4700
+ fifo_from_fir_fifo_cell11_sr_out[6] AO22XLTS
XU2235 n6382 FE_OFN535_n4699 FE_OFN1700_acc_fir_data_in_19_ FE_OFN523_n4700
+ fifo_from_fir_fifo_cell11_sr_out[19] AO22XLTS
XU2244 n6391 FE_OFN542_n4699 FE_OFN1749_acc_fir_data_in_10_ FE_OFN530_n4700
+ fifo_from_fir_fifo_cell11_sr_out[10] AO22XLTS
XU1608 n5857 FE_OFN206_n4513 FE_OFN1540_acc_fft_data_in_15_ FE_OFN194_n4514
+ fifo_from_fft_fifo_cell11_sr_out[15] AO22XLTS
XU1611 n5860 FE_OFN205_n4513 FE_OFN1556_acc_fft_data_in_12_ FE_OFN194_n4514
+ fifo_from_fft_fifo_cell11_sr_out[12] AO22XLTS
XU1609 n5858 FE_OFN206_n4513 FE_OFN1544_acc_fft_data_in_14_ FE_OFN194_n4514
+ fifo_from_fft_fifo_cell11_sr_out[14] AO22XLTS
XU1594 n5843 FE_OFN204_n4513 FE_OFN1466_acc_fft_data_in_29_ FE_OFN192_n4514
+ fifo_from_fft_fifo_cell11_sr_out[29] AO22XLTS
XU1601 n5850 FE_OFN207_n4513 FE_OFN1501_acc_fft_data_in_22_ FE_OFN195_n4514
+ fifo_from_fft_fifo_cell11_sr_out[22] AO22XLTS
XU1622 n5871 FE_OFN200_n4513 FE_OFN1618_acc_fft_data_in_1_ FE_OFN189_n4514
+ fifo_from_fft_fifo_cell11_sr_out[1] AO22XLTS
XU1603 n5852 FE_OFN203_n4513 FE_OFN1511_acc_fft_data_in_20_ FE_OFN190_n4514
+ fifo_from_fft_fifo_cell11_sr_out[20] AO22XLTS
XU1623 n5872 FE_OFN201_n4513 FE_OFN1624_acc_fft_data_in_0_ FE_OFN191_n4514
+ fifo_from_fft_fifo_cell11_sr_out[0] AO22XLTS
XU1604 n5853 FE_OFN205_n4513 FE_OFN1516_acc_fft_data_in_19_ FE_OFN193_n4514
+ fifo_from_fft_fifo_cell11_sr_out[19] AO22XLTS
XU1597 n5846 FE_OFN201_n4513 FE_OFN1481_acc_fft_data_in_26_ FE_OFN191_n4514
+ fifo_from_fft_fifo_cell11_sr_out[26] AO22XLTS
XU1621 n5870 FE_OFN197_n4513 FE_OFN1612_acc_fft_data_in_2_ FE_OFN189_n4514
+ fifo_from_fft_fifo_cell11_sr_out[2] AO22XLTS
XU1615 n5864 FE_OFN208_n4513 FE_OFN1578_acc_fft_data_in_8_ FE_OFN196_n4514
+ fifo_from_fft_fifo_cell11_sr_out[8] AO22XLTS
XU1599 n5848 FE_OFN197_n4513 FE_OFN1491_acc_fft_data_in_24_ FE_OFN187_n4514
+ fifo_from_fft_fifo_cell11_sr_out[24] AO22XLTS
XU1616 n5865 FE_OFN198_n4513 FE_OFN1584_acc_fft_data_in_7_ FE_OFN187_n4514
+ fifo_from_fft_fifo_cell11_sr_out[7] AO22XLTS
XU1600 n5849 FE_OFN202_n4513 FE_OFN1497_acc_fft_data_in_23_ FE_OFN190_n4514
+ fifo_from_fft_fifo_cell11_sr_out[23] AO22XLTS
XU1605 n5854 FE_OFN203_n4513 FE_OFN1522_acc_fft_data_in_18_ FE_OFN190_n4514
+ fifo_from_fft_fifo_cell11_sr_out[18] AO22XLTS
XU1606 n5855 FE_OFN205_n4513 FE_OFN1531_acc_fft_data_in_17_ FE_OFN193_n4514
+ fifo_from_fft_fifo_cell11_sr_out[17] AO22XLTS
XU1612 n5861 FE_OFN208_n4513 FE_OFN1561_acc_fft_data_in_11_ FE_OFN196_n4514
+ fifo_from_fft_fifo_cell11_sr_out[11] AO22XLTS
XU1620 n5869 FE_OFN201_n4513 FE_OFN1605_acc_fft_data_in_3_ FE_OFN191_n4514
+ fifo_from_fft_fifo_cell11_sr_out[3] AO22XLTS
XU1619 n5868 FE_OFN198_n4513 FE_OFN1601_acc_fft_data_in_4_ FE_OFN188_n4514
+ fifo_from_fft_fifo_cell11_sr_out[4] AO22XLTS
XU1602 n5851 FE_OFN207_n4513 FE_OFN1509_acc_fft_data_in_21_ FE_OFN195_n4514
+ fifo_from_fft_fifo_cell11_sr_out[21] AO22XLTS
XU1607 n5856 FE_OFN205_n4513 FE_OFN1536_acc_fft_data_in_16_ FE_OFN193_n4514
+ fifo_from_fft_fifo_cell11_sr_out[16] AO22XLTS
XU1613 n5862 FE_OFN208_n4513 FE_OFN1568_acc_fft_data_in_10_ FE_OFN196_n4514
+ fifo_from_fft_fifo_cell11_sr_out[10] AO22XLTS
XU1598 n5847 FE_OFN197_n4513 FE_OFN1485_acc_fft_data_in_25_ FE_OFN187_n4514
+ fifo_from_fft_fifo_cell11_sr_out[25] AO22XLTS
XU1596 n5845 FE_OFN200_n4513 FE_OFN1476_acc_fft_data_in_27_ FE_OFN189_n4514
+ fifo_from_fft_fifo_cell11_sr_out[27] AO22XLTS
XU1614 n5863 FE_OFN208_n4513 FE_OFN1573_acc_fft_data_in_9_ FE_OFN196_n4514
+ fifo_from_fft_fifo_cell11_sr_out[9] AO22XLTS
XU1617 n5866 FE_OFN202_n4513 FE_OFN1590_acc_fft_data_in_6_ FE_OFN188_n4514
+ fifo_from_fft_fifo_cell11_sr_out[6] AO22XLTS
XU1618 n5867 FE_OFN202_n4513 FE_OFN1595_acc_fft_data_in_5_ FE_OFN188_n4514
+ fifo_from_fft_fifo_cell11_sr_out[5] AO22XLTS
XU2221 n4695 n7544 n4698 n4693 OAI21XLTS
XU3540 fifo_to_fft_fifo_cell0_reg_ptok_N22 n9514 n5250 NAND2X1TS
XU3396 fifo_to_fir_fifo_cell0_reg_ptok_N22 n9515 n5208 NAND2XLTS
XU2195 n6345 FE_OFN522_n4693 FE_OFN1678_acc_fir_data_in_22_ FE_OFN449_n4694
+ fifo_from_fir_fifo_cell12_sr_out[22] AO22XLTS
XU1590 n4509 n7470 n4512 FE_OFN175_n4507 OAI21X1TS
XU2660 n4667 FE_OFN511_n4693 n4668 n4793 NAND3XLTS
XU2196 n6346 FE_OFN522_n4693 FE_OFN1688_acc_fir_data_in_21_ FE_OFN449_n4694
+ fifo_from_fir_fifo_cell12_sr_out[21] AO22XLTS
XU2220 n6369 fifo_from_fir_fifo_cell12_data_out_N35 n4697 n4695 OAI21XLTS
XU2186 n6336 FE_OFN514_n4693 FE_OFN1631_acc_fir_data_in_31_ FE_OFN452_n4694
+ fifo_from_fir_fifo_cell12_sr_out[31] AO22XLTS
XU2187 n6337 FE_OFN514_n4693 FE_OFN1635_acc_fir_data_in_30_ FE_OFN452_n4694
+ fifo_from_fir_fifo_cell12_sr_out[30] AO22XLTS
XU2661 n4792 n8874 n4794 fifo_from_fir_hang[11] n9465 OAI211XLTS
XU1565 n5817 FE_OFN185_n4507 FE_OFN1509_acc_fft_data_in_21_ FE_OFN113_n4508
+ fifo_from_fft_fifo_cell12_sr_out[21] AO22XLTS
XU2029 n4481 FE_OFN175_n4507 n4482 n4607 NAND3XLTS
XU2188 n6338 FE_OFN514_n4693 FE_OFN1643_acc_fir_data_in_29_ FE_OFN452_n4694
+ fifo_from_fir_fifo_cell12_sr_out[29] AO22XLTS
XU2197 n6347 FE_OFN517_n4693 FE_OFN1693_acc_fir_data_in_20_ FE_OFN443_n4694
+ fifo_from_fir_fifo_cell12_sr_out[20] AO22XLTS
XU1564 n5816 FE_OFN185_n4507 FE_OFN1500_acc_fft_data_in_22_ FE_OFN113_n4508
+ fifo_from_fft_fifo_cell12_sr_out[22] AO22XLTS
XU2194 n6344 FE_OFN518_n4693 FE_OFN1673_acc_fir_data_in_23_ n4694
+ fifo_from_fir_fifo_cell12_sr_out[23] AO22XLTS
XU1589 n5840 fifo_from_fft_fifo_cell12_data_out_N35 n4511 n4509 OAI21XLTS
XU1566 n5818 FE_OFN181_n4507 FE_OFN1511_acc_fft_data_in_20_ FE_OFN110_n4508
+ fifo_from_fft_fifo_cell12_sr_out[20] AO22XLTS
XU1556 n5808 FE_OFN182_n4507 FE_OFN1461_acc_fft_data_in_30_ FE_OFN111_n4508
+ fifo_from_fft_fifo_cell12_sr_out[30] AO22XLTS
XU2199 n6349 FE_OFN519_n4693 FE_OFN1706_acc_fir_data_in_18_ FE_OFN444_n4694
+ fifo_from_fir_fifo_cell12_sr_out[18] AO22XLTS
XU2198 n6348 FE_OFN517_n4693 FE_OFN1700_acc_fir_data_in_19_ FE_OFN443_n4694
+ fifo_from_fir_fifo_cell12_sr_out[19] AO22XLTS
XU2030 n4606 n8841 n4608 fifo_from_fft_hang[11] n9472 OAI211XLTS
XU1563 n5815 FE_OFN180_n4507 FE_OFN1494_acc_fft_data_in_23_ FE_OFN108_n4508
+ fifo_from_fft_fifo_cell12_sr_out[23] AO22XLTS
XU1557 n5809 FE_OFN184_n4507 FE_OFN1466_acc_fft_data_in_29_ FE_OFN111_n4508
+ fifo_from_fft_fifo_cell12_sr_out[29] AO22XLTS
XU2201 n6351 FE_OFN519_n4693 FE_OFN1717_acc_fir_data_in_16_ FE_OFN444_n4694
+ fifo_from_fir_fifo_cell12_sr_out[16] AO22XLTS
XU2200 n6350 FE_OFN519_n4693 FE_OFN1710_acc_fir_data_in_17_ FE_OFN444_n4694
+ fifo_from_fir_fifo_cell12_sr_out[17] AO22XLTS
XU2189 n6339 FE_OFN514_n4693 FE_OFN1650_acc_fir_data_in_28_ FE_OFN452_n4694
+ fifo_from_fir_fifo_cell12_sr_out[28] AO22XLTS
XU1555 n5807 FE_OFN184_n4507 FE_OFN1457_acc_fft_data_in_31_ FE_OFN111_n4508
+ fifo_from_fft_fifo_cell12_sr_out[31] AO22XLTS
XU2209 n6359 FE_OFN521_n4693 FE_OFN1760_acc_fir_data_in_8_ FE_OFN447_n4694
+ fifo_from_fir_fifo_cell12_sr_out[8] AO22XLTS
XU2214 n6364 FE_OFN516_n4693 FE_OFN1792_acc_fir_data_in_3_ FE_OFN445_n4694
+ fifo_from_fir_fifo_cell12_sr_out[3] AO22XLTS
XU2206 n6356 FE_OFN520_n4693 FE_OFN1743_acc_fir_data_in_11_ FE_OFN446_n4694
+ fifo_from_fir_fifo_cell12_sr_out[11] AO22XLTS
XU2205 n6355 FE_OFN522_n4693 FE_OFN1738_acc_fir_data_in_12_ FE_OFN449_n4694
+ fifo_from_fir_fifo_cell12_sr_out[12] AO22XLTS
XU2217 n6367 FE_OFN516_n4693 FE_OFN1813_acc_fir_data_in_0_ FE_OFN445_n4694
+ fifo_from_fir_fifo_cell12_sr_out[0] AO22XLTS
XU2203 n6353 FE_OFN522_n4693 FE_OFN1725_acc_fir_data_in_14_ FE_OFN449_n4694
+ fifo_from_fir_fifo_cell12_sr_out[14] AO22XLTS
XU1558 n5810 FE_OFN184_n4507 FE_OFN1470_acc_fft_data_in_28_ FE_OFN113_n4508
+ fifo_from_fft_fifo_cell12_sr_out[28] AO22XLTS
XU1567 n5819 FE_OFN180_n4507 FE_OFN1518_acc_fft_data_in_19_ FE_OFN108_n4508
+ fifo_from_fft_fifo_cell12_sr_out[19] AO22XLTS
XU1569 n5821 FE_OFN183_n4507 FE_OFN1528_acc_fft_data_in_17_ FE_OFN112_n4508
+ fifo_from_fft_fifo_cell12_sr_out[17] AO22XLTS
XU2211 n6361 FE_OFN513_n4693 FE_OFN1771_acc_fir_data_in_6_ FE_OFN448_n4694
+ fifo_from_fir_fifo_cell12_sr_out[6] AO22XLTS
XU2216 n6366 FE_OFN517_n4693 FE_OFN1803_acc_fir_data_in_1_ FE_OFN443_n4694
+ fifo_from_fir_fifo_cell12_sr_out[1] AO22XLTS
XU2213 n6363 FE_OFN516_n4693 FE_OFN1785_acc_fir_data_in_4_ FE_OFN445_n4694
+ fifo_from_fir_fifo_cell12_sr_out[4] AO22XLTS
XU2208 n6358 FE_OFN520_n4693 FE_OFN1755_acc_fir_data_in_9_ FE_OFN446_n4694
+ fifo_from_fir_fifo_cell12_sr_out[9] AO22XLTS
XU2202 n6352 FE_OFN521_n4693 FE_OFN1720_acc_fir_data_in_15_ FE_OFN447_n4694
+ fifo_from_fir_fifo_cell12_sr_out[15] AO22XLTS
XU2210 n6360 FE_OFN515_n4693 FE_OFN1768_acc_fir_data_in_7_ FE_OFN448_n4694
+ fifo_from_fir_fifo_cell12_sr_out[7] AO22XLTS
XU1568 n5820 FE_OFN181_n4507 FE_OFN1525_acc_fft_data_in_18_ FE_OFN108_n4508
+ fifo_from_fft_fifo_cell12_sr_out[18] AO22XLTS
XU2191 n6341 FE_OFN512_n4693 FE_OFN1657_acc_fir_data_in_26_ FE_OFN451_n4694
+ fifo_from_fir_fifo_cell12_sr_out[26] AO22XLTS
XU2190 n6340 FE_OFN513_n4693 FE_OFN1653_acc_fir_data_in_27_ FE_OFN450_n4694
+ fifo_from_fir_fifo_cell12_sr_out[27] AO22XLTS
XU2212 n6362 FE_OFN515_n4693 FE_OFN1782_acc_fir_data_in_5_ FE_OFN450_n4694
+ fifo_from_fir_fifo_cell12_sr_out[5] AO22XLTS
XU2215 n6365 FE_OFN515_n4693 FE_OFN1801_acc_fir_data_in_2_ FE_OFN448_n4694
+ fifo_from_fir_fifo_cell12_sr_out[2] AO22XLTS
XU2204 n6354 FE_OFN520_n4693 FE_OFN1735_acc_fir_data_in_13_ FE_OFN446_n4694
+ fifo_from_fir_fifo_cell12_sr_out[13] AO22XLTS
XU2193 n6343 FE_OFN512_n4693 FE_OFN1670_acc_fir_data_in_24_ FE_OFN451_n4694
+ fifo_from_fir_fifo_cell12_sr_out[24] AO22XLTS
XU2192 n6342 FE_OFN512_n4693 FE_OFN1665_acc_fir_data_in_25_ FE_OFN451_n4694
+ fifo_from_fir_fifo_cell12_sr_out[25] AO22XLTS
XU1570 n5822 FE_OFN180_n4507 FE_OFN1537_acc_fft_data_in_16_ FE_OFN110_n4508
+ fifo_from_fft_fifo_cell12_sr_out[16] AO22XLTS
XU2207 n6357 FE_OFN521_n4693 FE_OFN1747_acc_fir_data_in_10_ FE_OFN447_n4694
+ fifo_from_fir_fifo_cell12_sr_out[10] AO22XLTS
XU1583 n5835 FE_OFN182_n4507 FE_OFN1605_acc_fft_data_in_3_ FE_OFN109_n4508
+ fifo_from_fft_fifo_cell12_sr_out[3] AO22XLTS
XU1585 n5837 FE_OFN179_n4507 FE_OFN1617_acc_fft_data_in_1_ FE_OFN107_n4508
+ fifo_from_fft_fifo_cell12_sr_out[1] AO22XLTS
XU1582 n5834 FE_OFN176_n4507 FE_OFN1601_acc_fft_data_in_4_ n4508
+ fifo_from_fft_fifo_cell12_sr_out[4] AO22XLTS
XU1586 n5838 FE_OFN182_n4507 FE_OFN1624_acc_fft_data_in_0_ FE_OFN109_n4508
+ fifo_from_fft_fifo_cell12_sr_out[0] AO22XLTS
XU1576 n5828 FE_OFN186_n4507 FE_OFN1568_acc_fft_data_in_10_ FE_OFN114_n4508
+ fifo_from_fft_fifo_cell12_sr_out[10] AO22XLTS
XU1575 n5827 FE_OFN186_n4507 FE_OFN1559_acc_fft_data_in_11_ FE_OFN114_n4508
+ fifo_from_fft_fifo_cell12_sr_out[11] AO22XLTS
XU1560 n5812 FE_OFN179_n4507 FE_OFN1480_acc_fft_data_in_26_ FE_OFN109_n4508
+ fifo_from_fft_fifo_cell12_sr_out[26] AO22XLTS
XU1577 n5829 FE_OFN186_n4507 FE_OFN1571_acc_fft_data_in_9_ FE_OFN114_n4508
+ fifo_from_fft_fifo_cell12_sr_out[9] AO22XLTS
XU1580 n5832 FE_OFN177_n4507 FE_OFN1590_acc_fft_data_in_6_ FE_OFN106_n4508
+ fifo_from_fft_fifo_cell12_sr_out[6] AO22XLTS
XU2184 n4689 n7539 n4692 n8376 OAI21XLTS
XU1574 n5826 FE_OFN183_n4507 FE_OFN1553_acc_fft_data_in_12_ FE_OFN112_n4508
+ fifo_from_fft_fifo_cell12_sr_out[12] AO22XLTS
XU1559 n5811 FE_OFN179_n4507 FE_OFN1475_acc_fft_data_in_27_ FE_OFN107_n4508
+ fifo_from_fft_fifo_cell12_sr_out[27] AO22XLTS
XU1573 n5825 FE_OFN181_n4507 FE_OFN1548_acc_fft_data_in_13_ FE_OFN110_n4508
+ fifo_from_fft_fifo_cell12_sr_out[13] AO22XLTS
XU1561 n5813 FE_OFN178_n4507 FE_OFN1486_acc_fft_data_in_25_ FE_OFN105_n4508
+ fifo_from_fft_fifo_cell12_sr_out[25] AO22XLTS
XU1579 n5831 FE_OFN177_n4507 FE_OFN1582_acc_fft_data_in_7_ FE_OFN106_n4508
+ fifo_from_fft_fifo_cell12_sr_out[7] AO22XLTS
XU1584 n5836 FE_OFN178_n4507 FE_OFN1610_acc_fft_data_in_2_ FE_OFN107_n4508
+ fifo_from_fft_fifo_cell12_sr_out[2] AO22XLTS
XU1572 n5824 FE_OFN183_n4507 FE_OFN1543_acc_fft_data_in_14_ FE_OFN112_n4508
+ fifo_from_fft_fifo_cell12_sr_out[14] AO22XLTS
XU1562 n5814 FE_OFN178_n4507 FE_OFN1489_acc_fft_data_in_24_ FE_OFN105_n4508
+ fifo_from_fft_fifo_cell12_sr_out[24] AO22XLTS
XU1581 n5833 FE_OFN177_n4507 FE_OFN1595_acc_fft_data_in_5_ FE_OFN106_n4508
+ fifo_from_fft_fifo_cell12_sr_out[5] AO22XLTS
XU1571 n5823 FE_OFN183_n4507 FE_OFN1538_acc_fft_data_in_15_ FE_OFN112_n4508
+ fifo_from_fft_fifo_cell12_sr_out[15] AO22XLTS
XU1578 n5830 FE_OFN186_n4507 FE_OFN1579_acc_fft_data_in_8_ FE_OFN114_n4508
+ fifo_from_fft_fifo_cell12_sr_out[8] AO22XLTS
XU2658 n4669 n8376 n4670 n4790 NAND3XLTS
XU2158 n6311 n8382 FE_OFN1679_acc_fir_data_in_22_ FE_OFN462_n4688
+ fifo_from_fir_fifo_cell13_sr_out[22] AO22XLTS
XU2183 n6335 fifo_from_fir_fifo_cell13_data_out_N35 n4691 n4689 OAI21XLTS
XU1553 n4503 n7465 n4506 n8711 OAI21XLTS
XU2159 n6312 n8382 FE_OFN1685_acc_fir_data_in_21_ FE_OFN462_n4688
+ fifo_from_fir_fifo_cell13_sr_out[21] AO22XLTS
XU2157 n6310 n8382 FE_OFN1677_acc_fir_data_in_23_ FE_OFN462_n4688
+ fifo_from_fir_fifo_cell13_sr_out[23] AO22XLTS
XU1527 n5782 n8717 FE_OFN1504_acc_fft_data_in_22_ FE_OFN123_n4502
+ fifo_from_fft_fifo_cell13_sr_out[22] AO22XLTS
XU2151 n6304 n8384 FE_OFN1644_acc_fir_data_in_29_ FE_OFN455_n4688
+ fifo_from_fir_fifo_cell13_sr_out[29] AO22XLTS
XU2027 n4483 n8711 n4484 n4604 NAND3XLTS
XU2162 n6315 n8381 FE_OFN1706_acc_fir_data_in_18_ FE_OFN459_n4688
+ fifo_from_fir_fifo_cell13_sr_out[18] AO22XLTS
XU2163 n6316 n8381 FE_OFN1711_acc_fir_data_in_17_ FE_OFN458_n4688
+ fifo_from_fir_fifo_cell13_sr_out[17] AO22XLTS
XU2150 n6303 n8384 FE_OFN1636_acc_fir_data_in_30_ FE_OFN455_n4688
+ fifo_from_fir_fifo_cell13_sr_out[30] AO22XLTS
XU2161 n6314 n8381 FE_OFN1697_acc_fir_data_in_19_ FE_OFN458_n4688
+ fifo_from_fir_fifo_cell13_sr_out[19] AO22XLTS
XU2164 n6317 n8381 FE_OFN1718_acc_fir_data_in_16_ FE_OFN458_n4688
+ fifo_from_fir_fifo_cell13_sr_out[16] AO22XLTS
XU2659 n4789 n8874 n4791 fifo_from_fir_hang[12] n9468 OAI211XLTS
XU1552 n5806 fifo_from_fft_fifo_cell13_data_out_N35 n4505 n4503 OAI21XLTS
XU2149 n6302 n8384 FE_OFN1631_acc_fir_data_in_31_ FE_OFN455_n4688
+ fifo_from_fir_fifo_cell13_sr_out[31] AO22XLTS
XU2160 n6313 n8382 FE_OFN1694_acc_fir_data_in_20_ FE_OFN462_n4688
+ fifo_from_fir_fifo_cell13_sr_out[20] AO22XLTS
XU2152 n6305 n8384 FE_OFN1649_acc_fir_data_in_28_ FE_OFN455_n4688
+ fifo_from_fir_fifo_cell13_sr_out[28] AO22XLTS
XU1518 n5773 n8719 FE_OFN1456_acc_fft_data_in_31_ FE_OFN118_n4502
+ fifo_from_fft_fifo_cell13_sr_out[31] AO22XLTS
XU2028 n4603 n8841 n4605 fifo_from_fft_hang[12] n9470 OAI211XLTS
XU1526 n5781 n8717 FE_OFN1495_acc_fft_data_in_23_ FE_OFN124_n4502
+ fifo_from_fft_fifo_cell13_sr_out[23] AO22XLTS
XU1531 n5786 n8716 FE_OFN1526_acc_fft_data_in_18_ FE_OFN128_n4502
+ fifo_from_fft_fifo_cell13_sr_out[18] AO22XLTS
XU1530 n5785 n8716 FE_OFN1515_acc_fft_data_in_19_ FE_OFN128_n4502
+ fifo_from_fft_fifo_cell13_sr_out[19] AO22XLTS
XU1533 n5788 n8716 FE_OFN1535_acc_fft_data_in_16_ FE_OFN128_n4502
+ fifo_from_fft_fifo_cell13_sr_out[16] AO22XLTS
XU1519 n5774 n8719 FE_OFN1462_acc_fft_data_in_30_ FE_OFN118_n4502
+ fifo_from_fft_fifo_cell13_sr_out[30] AO22XLTS
XU1520 n5775 n8719 FE_OFN1467_acc_fft_data_in_29_ FE_OFN118_n4502
+ fifo_from_fft_fifo_cell13_sr_out[29] AO22XLTS
XU1532 n5787 n8716 FE_OFN1532_acc_fft_data_in_17_ FE_OFN128_n4502
+ fifo_from_fft_fifo_cell13_sr_out[17] AO22XLTS
XU1529 n5784 n8717 FE_OFN1513_acc_fft_data_in_20_ FE_OFN124_n4502
+ fifo_from_fft_fifo_cell13_sr_out[20] AO22XLTS
XU1528 n5783 n8717 FE_OFN1508_acc_fft_data_in_21_ FE_OFN123_n4502
+ fifo_from_fft_fifo_cell13_sr_out[21] AO22XLTS
XU2153 n6306 n8383 FE_OFN1654_acc_fir_data_in_27_ FE_OFN453_n4688
+ fifo_from_fir_fifo_cell13_sr_out[27] AO22XLTS
XU2156 n6309 n8383 FE_OFN1668_acc_fir_data_in_24_ FE_OFN453_n4688
+ fifo_from_fir_fifo_cell13_sr_out[24] AO22XLTS
XU2174 n6327 n8378 FE_OFN1776_acc_fir_data_in_6_ FE_OFN454_n4688
+ fifo_from_fir_fifo_cell13_sr_out[6] AO22XLTS
XU2179 n6332 n8377 FE_OFN1802_acc_fir_data_in_1_ FE_OFN457_n4688
+ fifo_from_fir_fifo_cell13_sr_out[1] AO22XLTS
XU2173 n6326 n8378 FE_OFN1768_acc_fir_data_in_7_ FE_OFN454_n4688
+ fifo_from_fir_fifo_cell13_sr_out[7] AO22XLTS
XU2176 n6329 n8378 FE_OFN1789_acc_fir_data_in_4_ FE_OFN454_n4688
+ fifo_from_fir_fifo_cell13_sr_out[4] AO22XLTS
XU2154 n6307 n8383 FE_OFN1660_acc_fir_data_in_26_ FE_OFN453_n4688
+ fifo_from_fir_fifo_cell13_sr_out[26] AO22XLTS
XU2168 n6321 n8380 FE_OFN1740_acc_fir_data_in_12_ FE_OFN460_n4688
+ fifo_from_fir_fifo_cell13_sr_out[12] AO22XLTS
XU2167 n6320 n8380 FE_OFN1735_acc_fir_data_in_13_ FE_OFN459_n4688
+ fifo_from_fir_fifo_cell13_sr_out[13] AO22XLTS
XU2172 n6325 n8379 FE_OFN1758_acc_fir_data_in_8_ FE_OFN461_n4688
+ fifo_from_fir_fifo_cell13_sr_out[8] AO22XLTS
XU2177 n6330 n8377 FE_OFN1792_acc_fir_data_in_3_ FE_OFN457_n4688
+ fifo_from_fir_fifo_cell13_sr_out[3] AO22XLTS
XU2155 n6308 n8383 FE_OFN1662_acc_fir_data_in_25_ n4688
+ fifo_from_fir_fifo_cell13_sr_out[25] AO22XLTS
XU2169 n6322 n8379 FE_OFN1743_acc_fir_data_in_11_ FE_OFN461_n4688
+ fifo_from_fir_fifo_cell13_sr_out[11] AO22XLTS
XU2180 n6333 n8377 FE_OFN1814_acc_fir_data_in_0_ FE_OFN457_n4688
+ fifo_from_fir_fifo_cell13_sr_out[0] AO22XLTS
XU2178 n6331 n8377 FE_OFN1799_acc_fir_data_in_2_ FE_OFN456_n4688
+ fifo_from_fir_fifo_cell13_sr_out[2] AO22XLTS
XU2175 n6328 n8378 FE_OFN1779_acc_fir_data_in_5_ n4688
+ fifo_from_fir_fifo_cell13_sr_out[5] AO22XLTS
XU2165 n6318 n8380 FE_OFN1722_acc_fir_data_in_15_ FE_OFN460_n4688
+ fifo_from_fir_fifo_cell13_sr_out[15] AO22XLTS
XU2171 n6324 n8379 FE_OFN1755_acc_fir_data_in_9_ FE_OFN461_n4688
+ fifo_from_fir_fifo_cell13_sr_out[9] AO22XLTS
XU1521 n5776 n8719 FE_OFN1471_acc_fft_data_in_28_ FE_OFN116_n4502
+ fifo_from_fft_fifo_cell13_sr_out[28] AO22XLTS
XU2166 n6319 n8380 FE_OFN1729_acc_fir_data_in_14_ FE_OFN460_n4688
+ fifo_from_fir_fifo_cell13_sr_out[14] AO22XLTS
XU2170 n6323 n8379 FE_OFN1750_acc_fir_data_in_10_ FE_OFN461_n4688
+ fifo_from_fir_fifo_cell13_sr_out[10] AO22XLTS
XU1538 n5793 n8714 FE_OFN1562_acc_fft_data_in_11_ FE_OFN125_n4502
+ fifo_from_fft_fifo_cell13_sr_out[11] AO22XLTS
XU1522 n5777 n8718 FE_OFN1477_acc_fft_data_in_27_ FE_OFN122_n4502
+ fifo_from_fft_fifo_cell13_sr_out[27] AO22XLTS
XU1523 n5778 n8718 FE_OFN1482_acc_fft_data_in_26_ FE_OFN122_n4502
+ fifo_from_fft_fifo_cell13_sr_out[26] AO22XLTS
XU1524 n5779 n8718 FE_OFN1487_acc_fft_data_in_25_ FE_OFN120_n4502
+ fifo_from_fft_fifo_cell13_sr_out[25] AO22XLTS
XU1545 n5800 n8713 FE_OFN1602_acc_fft_data_in_4_ n4502
+ fifo_from_fft_fifo_cell13_sr_out[4] AO22XLTS
XU1544 n5799 n8713 FE_OFN1595_acc_fft_data_in_5_ FE_OFN116_n4502
+ fifo_from_fft_fifo_cell13_sr_out[5] AO22XLTS
XU1542 n5797 n8713 FE_OFN1580_acc_fft_data_in_7_ FE_OFN115_n4502
+ fifo_from_fft_fifo_cell13_sr_out[7] AO22XLTS
XU1543 n5798 n8713 FE_OFN1590_acc_fft_data_in_6_ FE_OFN115_n4502
+ fifo_from_fft_fifo_cell13_sr_out[6] AO22XLTS
XU1540 n5795 n8714 FE_OFN1572_acc_fft_data_in_9_ FE_OFN125_n4502
+ fifo_from_fft_fifo_cell13_sr_out[9] AO22XLTS
XU1537 n5792 n8715 FE_OFN1557_acc_fft_data_in_12_ FE_OFN127_n4502
+ fifo_from_fft_fifo_cell13_sr_out[12] AO22XLTS
XU1547 n5802 n8712 FE_OFN1613_acc_fft_data_in_2_ FE_OFN119_n4502
+ fifo_from_fft_fifo_cell13_sr_out[2] AO22XLTS
XU1536 n5791 n8715 FE_OFN1552_acc_fft_data_in_13_ FE_OFN126_n4502
+ fifo_from_fft_fifo_cell13_sr_out[13] AO22XLTS
XU1535 n5790 n8715 FE_OFN1545_acc_fft_data_in_14_ FE_OFN127_n4502
+ fifo_from_fft_fifo_cell13_sr_out[14] AO22XLTS
XU1539 n5794 n8714 FE_OFN1567_acc_fft_data_in_10_ FE_OFN125_n4502
+ fifo_from_fft_fifo_cell13_sr_out[10] AO22XLTS
XU1549 n5804 n8712 FE_OFN1626_acc_fft_data_in_0_ FE_OFN122_n4502
+ fifo_from_fft_fifo_cell13_sr_out[0] AO22XLTS
XU1534 n5789 n8715 FE_OFN1541_acc_fft_data_in_15_ FE_OFN126_n4502
+ fifo_from_fft_fifo_cell13_sr_out[15] AO22XLTS
XU1546 n5801 n8712 FE_OFN1606_acc_fft_data_in_3_ FE_OFN122_n4502
+ fifo_from_fft_fifo_cell13_sr_out[3] AO22XLTS
XU1541 n5796 n8714 FE_OFN1576_acc_fft_data_in_8_ FE_OFN126_n4502
+ fifo_from_fft_fifo_cell13_sr_out[8] AO22XLTS
XU1525 n5780 n8718 FE_OFN1492_acc_fft_data_in_24_ FE_OFN120_n4502
+ fifo_from_fft_fifo_cell13_sr_out[24] AO22XLTS
XU1548 n5803 n8712 FE_OFN1621_acc_fft_data_in_1_ FE_OFN119_n4502
+ fifo_from_fft_fifo_cell13_sr_out[1] AO22XLTS
XU2147 n4683 n7534 n4686 FE_OFN496_n4681 OAI21XLTS
XU1516 n4497 n7460 n4500 FE_OFN161_n4495 OAI21X1TS
XU2146 n6301 fifo_from_fir_fifo_cell14_data_out_N35 n4685 n4683 OAI21XLTS
XU2656 n4671 FE_OFN496_n4681 n4672 n4787 NAND3XLTS
XU2122 n6278 FE_OFN504_n4681 FE_OFN1689_acc_fir_data_in_21_ FE_OFN486_n4682
+ fifo_from_fir_fifo_cell14_sr_out[21] AO22XLTS
XU2657 n4786 n8874 n4788 fifo_from_fir_hang[13] n9469 OAI211XLTS
XU2138 n6294 FE_OFN500_n4681 FE_OFN1778_acc_fir_data_in_5_ FE_OFN490_n4682
+ fifo_from_fir_fifo_cell14_sr_out[5] AO22XLTS
XU1515 n5772 fifo_from_fft_fifo_cell14_data_out_N35 n4499 n4497 OAI21XLTS
XU2137 n6293 FE_OFN500_n4681 FE_OFN1775_acc_fir_data_in_6_ FE_OFN492_n4682
+ fifo_from_fir_fifo_cell14_sr_out[6] AO22XLTS
XU2136 n6292 FE_OFN500_n4681 FE_OFN1762_acc_fir_data_in_7_ FE_OFN490_n4682
+ fifo_from_fir_fifo_cell14_sr_out[7] AO22XLTS
XU2139 n6295 FE_OFN501_n4681 FE_OFN1788_acc_fir_data_in_4_ FE_OFN488_n4682
+ fifo_from_fir_fifo_cell14_sr_out[4] AO22XLTS
XU2025 n4485 n4495 n4486 n4601 NAND3XLTS
XU1491 n5749 FE_OFN171_n4495 FE_OFN1507_acc_fft_data_in_21_ FE_OFN157_n4496
+ fifo_from_fft_fifo_cell14_sr_out[21] AO22XLTS
XU2112 n6268 FE_OFN499_n4681 FE_OFN1628_acc_fir_data_in_31_ FE_OFN493_n4682
+ fifo_from_fir_fifo_cell14_sr_out[31] AO22XLTS
XU2113 n6269 FE_OFN498_n4681 FE_OFN1635_acc_fir_data_in_30_ FE_OFN492_n4682
+ fifo_from_fir_fifo_cell14_sr_out[30] AO22XLTS
XU2120 n6276 FE_OFN503_n4681 FE_OFN1671_acc_fir_data_in_23_ FE_OFN487_n4682
+ fifo_from_fir_fifo_cell14_sr_out[23] AO22XLTS
XU2121 n6277 FE_OFN504_n4681 FE_OFN1679_acc_fir_data_in_22_ FE_OFN486_n4682
+ fifo_from_fir_fifo_cell14_sr_out[22] AO22XLTS
XU2123 n6279 FE_OFN504_n4681 FE_OFN1691_acc_fir_data_in_20_ FE_OFN487_n4682
+ fifo_from_fir_fifo_cell14_sr_out[20] AO22XLTS
XU2114 n6270 FE_OFN499_n4681 FE_OFN1638_acc_fir_data_in_29_ FE_OFN493_n4682
+ fifo_from_fir_fifo_cell14_sr_out[29] AO22XLTS
XU1481 n5739 FE_OFN171_n4495 FE_OFN1453_acc_fft_data_in_31_ FE_OFN157_n4496
+ fifo_from_fft_fifo_cell14_sr_out[31] AO22XLTS
XU2026 n4600 n8841 n4602 fifo_from_fft_hang[13] n9472 OAI211XLTS
XU1482 n5740 FE_OFN170_n4495 FE_OFN1460_acc_fft_data_in_30_ FE_OFN155_n4496
+ fifo_from_fft_fifo_cell14_sr_out[30] AO22XLTS
XU1490 n5748 FE_OFN171_n4495 FE_OFN1501_acc_fft_data_in_22_ FE_OFN157_n4496
+ fifo_from_fft_fifo_cell14_sr_out[22] AO22XLTS
XU1489 n5747 FE_OFN169_n4495 FE_OFN1495_acc_fft_data_in_23_ FE_OFN154_n4496
+ fifo_from_fft_fifo_cell14_sr_out[23] AO22XLTS
XU1483 n5741 FE_OFN170_n4495 FE_OFN1466_acc_fft_data_in_29_ FE_OFN155_n4496
+ fifo_from_fft_fifo_cell14_sr_out[29] AO22XLTS
XU1492 n5750 FE_OFN169_n4495 FE_OFN1512_acc_fft_data_in_20_ FE_OFN154_n4496
+ fifo_from_fft_fifo_cell14_sr_out[20] AO22XLTS
XU1507 n5765 FE_OFN166_n4495 FE_OFN1592_acc_fft_data_in_5_ FE_OFN154_n4496
+ fifo_from_fft_fifo_cell14_sr_out[5] AO22XLTS
XU1506 n5764 FE_OFN169_n4495 FE_OFN1589_acc_fft_data_in_6_ FE_OFN156_n4496
+ fifo_from_fft_fifo_cell14_sr_out[6] AO22XLTS
XU1505 n5763 FE_OFN164_n4495 FE_OFN1583_acc_fft_data_in_7_ FE_OFN151_n4496
+ fifo_from_fft_fifo_cell14_sr_out[7] AO22XLTS
XU1508 n5766 FE_OFN163_n4495 FE_OFN1599_acc_fft_data_in_4_ FE_OFN158_n4496
+ fifo_from_fft_fifo_cell14_sr_out[4] AO22XLTS
XU2115 n6271 FE_OFN499_n4681 FE_OFN1646_acc_fir_data_in_28_ FE_OFN493_n4682
+ fifo_from_fir_fifo_cell14_sr_out[28] AO22XLTS
XU2141 n6297 FE_OFN501_n4681 FE_OFN1796_acc_fir_data_in_2_ FE_OFN488_n4682
+ fifo_from_fir_fifo_cell14_sr_out[2] AO22XLTS
XU2124 n6280 FE_OFN503_n4681 FE_OFN1698_acc_fir_data_in_19_ FE_OFN487_n4682
+ fifo_from_fir_fifo_cell14_sr_out[19] AO22XLTS
XU2142 n6298 FE_OFN502_n4681 FE_OFN1805_acc_fir_data_in_1_ n4682
+ fifo_from_fir_fifo_cell14_sr_out[1] AO22XLTS
XU2135 n6291 FE_OFN507_n4681 FE_OFN1757_acc_fir_data_in_8_ FE_OFN495_n4682
+ fifo_from_fir_fifo_cell14_sr_out[8] AO22XLTS
XU2126 n6282 FE_OFN505_n4681 FE_OFN1710_acc_fir_data_in_17_ FE_OFN491_n4682
+ fifo_from_fir_fifo_cell14_sr_out[17] AO22XLTS
XU2125 n6281 FE_OFN505_n4681 FE_OFN1702_acc_fir_data_in_18_ FE_OFN491_n4682
+ fifo_from_fir_fifo_cell14_sr_out[18] AO22XLTS
XU2117 n6273 FE_OFN498_n4681 FE_OFN1658_acc_fir_data_in_26_ FE_OFN494_n4682
+ fifo_from_fir_fifo_cell14_sr_out[26] AO22XLTS
XU2127 n6283 FE_OFN505_n4681 FE_OFN1712_acc_fir_data_in_16_ FE_OFN491_n4682
+ fifo_from_fir_fifo_cell14_sr_out[16] AO22XLTS
XU2116 n6272 FE_OFN498_n4681 FE_OFN1651_acc_fir_data_in_27_ FE_OFN494_n4682
+ fifo_from_fir_fifo_cell14_sr_out[27] AO22XLTS
XU2140 n6296 FE_OFN502_n4681 FE_OFN1794_acc_fir_data_in_3_ n4682
+ fifo_from_fir_fifo_cell14_sr_out[3] AO22XLTS
XU2128 n6284 FE_OFN506_n4681 FE_OFN1722_acc_fir_data_in_15_ FE_OFN489_n4682
+ fifo_from_fir_fifo_cell14_sr_out[15] AO22XLTS
XU2129 n6285 FE_OFN506_n4681 FE_OFN1729_acc_fir_data_in_14_ FE_OFN489_n4682
+ fifo_from_fir_fifo_cell14_sr_out[14] AO22XLTS
XU2132 n6288 FE_OFN507_n4681 FE_OFN1741_acc_fir_data_in_11_ FE_OFN495_n4682
+ fifo_from_fir_fifo_cell14_sr_out[11] AO22XLTS
XU2143 n6299 FE_OFN501_n4681 FE_OFN1812_acc_fir_data_in_0_ FE_OFN488_n4682
+ fifo_from_fir_fifo_cell14_sr_out[0] AO22XLTS
XU1484 n5742 FE_OFN170_n4495 FE_OFN1470_acc_fft_data_in_28_ FE_OFN155_n4496
+ fifo_from_fft_fifo_cell14_sr_out[28] AO22XLTS
XU2118 n6274 FE_OFN497_n4681 FE_OFN1664_acc_fir_data_in_25_ FE_OFN494_n4682
+ fifo_from_fir_fifo_cell14_sr_out[25] AO22XLTS
XU2133 n6289 FE_OFN506_n4681 FE_OFN1750_acc_fir_data_in_10_ FE_OFN489_n4682
+ fifo_from_fir_fifo_cell14_sr_out[10] AO22XLTS
XU2134 n6290 FE_OFN507_n4681 FE_OFN1753_acc_fir_data_in_9_ FE_OFN495_n4682
+ fifo_from_fir_fifo_cell14_sr_out[9] AO22XLTS
XU2119 n6275 FE_OFN497_n4681 FE_OFN1669_acc_fir_data_in_24_ FE_OFN494_n4682
+ fifo_from_fir_fifo_cell14_sr_out[24] AO22XLTS
XU2131 n6287 FE_OFN506_n4681 FE_OFN1740_acc_fir_data_in_12_ FE_OFN489_n4682
+ fifo_from_fir_fifo_cell14_sr_out[12] AO22XLTS
XU1503 n5761 FE_OFN172_n4495 FE_OFN1573_acc_fft_data_in_9_ FE_OFN160_n4496
+ fifo_from_fft_fifo_cell14_sr_out[9] AO22XLTS
XU1495 n5753 FE_OFN165_n4495 FE_OFN1530_acc_fft_data_in_17_ FE_OFN158_n4496
+ fifo_from_fft_fifo_cell14_sr_out[17] AO22XLTS
XU1496 n5754 FE_OFN165_n4495 FE_OFN1535_acc_fft_data_in_16_ FE_OFN158_n4496
+ fifo_from_fft_fifo_cell14_sr_out[16] AO22XLTS
XU1501 n5759 FE_OFN172_n4495 FE_OFN1560_acc_fft_data_in_11_ FE_OFN160_n4496
+ fifo_from_fft_fifo_cell14_sr_out[11] AO22XLTS
XU1494 n5752 FE_OFN169_n4495 FE_OFN1525_acc_fft_data_in_18_ FE_OFN156_n4496
+ fifo_from_fft_fifo_cell14_sr_out[18] AO22XLTS
XU1497 n5755 FE_OFN167_n4495 FE_OFN1539_acc_fft_data_in_15_ FE_OFN159_n4496
+ fifo_from_fft_fifo_cell14_sr_out[15] AO22XLTS
XU1498 n5756 FE_OFN167_n4495 FE_OFN1545_acc_fft_data_in_14_ FE_OFN159_n4496
+ fifo_from_fft_fifo_cell14_sr_out[14] AO22XLTS
XU1493 n5751 FE_OFN163_n4495 FE_OFN1517_acc_fft_data_in_19_ FE_OFN158_n4496
+ fifo_from_fft_fifo_cell14_sr_out[19] AO22XLTS
XU1502 n5760 FE_OFN172_n4495 FE_OFN1565_acc_fft_data_in_10_ FE_OFN160_n4496
+ fifo_from_fft_fifo_cell14_sr_out[10] AO22XLTS
XU1500 n5758 FE_OFN165_n4495 FE_OFN1554_acc_fft_data_in_12_ FE_OFN159_n4496
+ fifo_from_fft_fifo_cell14_sr_out[12] AO22XLTS
XU1504 n5762 FE_OFN172_n4495 FE_OFN1578_acc_fft_data_in_8_ FE_OFN160_n4496
+ fifo_from_fft_fifo_cell14_sr_out[8] AO22XLTS
XU1487 n5745 FE_OFN162_n4495 FE_OFN1484_acc_fft_data_in_25_ n4496
+ fifo_from_fft_fifo_cell14_sr_out[25] AO22XLTS
XU1510 n5768 FE_OFN164_n4495 FE_OFN1610_acc_fft_data_in_2_ FE_OFN151_n4496
+ fifo_from_fft_fifo_cell14_sr_out[2] AO22XLTS
XU1509 n5767 FE_OFN168_n4495 FE_OFN1604_acc_fft_data_in_3_ FE_OFN153_n4496
+ fifo_from_fft_fifo_cell14_sr_out[3] AO22XLTS
XU1511 n5769 FE_OFN164_n4495 FE_OFN1616_acc_fft_data_in_1_ FE_OFN151_n4496
+ fifo_from_fft_fifo_cell14_sr_out[1] AO22XLTS
XU1485 n5743 FE_OFN166_n4495 FE_OFN1474_acc_fft_data_in_27_ FE_OFN152_n4496
+ fifo_from_fft_fifo_cell14_sr_out[27] AO22XLTS
XU1486 n5744 FE_OFN166_n4495 FE_OFN1478_acc_fft_data_in_26_ FE_OFN152_n4496
+ fifo_from_fft_fifo_cell14_sr_out[26] AO22XLTS
XU1512 n5770 FE_OFN168_n4495 FE_OFN1623_acc_fft_data_in_0_ FE_OFN153_n4496
+ fifo_from_fft_fifo_cell14_sr_out[0] AO22XLTS
XU1488 n5746 FE_OFN162_n4495 FE_OFN1490_acc_fft_data_in_24_ n4496
+ fifo_from_fft_fifo_cell14_sr_out[24] AO22XLTS
XU2110 n4677 n7529 n4680 n4675 OAI21X1TS
XU2102 n6261 FE_OFN478_n4675 FE_OFN1786_acc_fir_data_in_4_ FE_OFN465_n4676
+ fifo_from_fir_fifo_cell15_sr_out[4] AO22XLTS
XU2654 n4673 FE_OFN474_n4675 n4674 n4784 NAND3XLTS
XU3612 n4785 n4674 INVXLTS
XU2109 n6267 fifo_from_fir_fifo_cell15_data_out_N35 n4679 n4677 OAI21XLTS
XU1479 n4491 n7455 n4494 n4489 OAI21XLTS
XU2023 n4487 n4489 n4488 n4598 NAND3XLTS
XU1478 n5738 fifo_from_fft_fifo_cell15_data_out_N35 n4493 n4491 OAI21XLTS
XU3755 n4599 n4488 INVXLTS
XU2101 n6260 FE_OFN475_n4675 FE_OFN1781_acc_fir_data_in_5_ FE_OFN467_n4676
+ fifo_from_fir_fifo_cell15_sr_out[5] AO22XLTS
XU1471 n5732 FE_OFN143_n4489 FE_OFN1597_acc_fft_data_in_4_ FE_OFN129_n4490
+ fifo_from_fft_fifo_cell15_sr_out[4] AO22XLTS
XU2100 n6259 FE_OFN478_n4675 FE_OFN1770_acc_fir_data_in_6_ FE_OFN465_n4676
+ fifo_from_fir_fifo_cell15_sr_out[6] AO22XLTS
XU2099 n6258 FE_OFN478_n4675 FE_OFN1765_acc_fir_data_in_7_ FE_OFN465_n4676
+ fifo_from_fir_fifo_cell15_sr_out[7] AO22XLTS
XU2096 n6255 FE_OFN483_n4675 FE_OFN1746_acc_fir_data_in_10_ FE_OFN471_n4676
+ fifo_from_fir_fifo_cell15_sr_out[10] AO22XLTS
XU2080 n6239 FE_OFN476_n4675 FE_OFN1818_acc_fir_data_in_26_ FE_OFN469_n4676
+ fifo_from_fir_fifo_cell15_sr_out[26] AO22XLTS
XU2097 n6256 FE_OFN484_n4675 FE_OFN1755_acc_fir_data_in_9_ FE_OFN472_n4676
+ fifo_from_fir_fifo_cell15_sr_out[9] AO22XLTS
XU2089 n6248 FE_OFN481_n4675 FE_OFN1710_acc_fir_data_in_17_ FE_OFN466_n4676
+ fifo_from_fir_fifo_cell15_sr_out[17] AO22XLTS
XU2076 n6235 FE_OFN476_n4675 FE_OFN1633_acc_fir_data_in_30_ FE_OFN470_n4676
+ fifo_from_fir_fifo_cell15_sr_out[30] AO22XLTS
XU2082 n6241 FE_OFN475_n4675 FE_OFN1669_acc_fir_data_in_24_ FE_OFN469_n4676
+ fifo_from_fir_fifo_cell15_sr_out[24] AO22XLTS
XU2075 n6234 FE_OFN477_n4675 FE_OFN1632_acc_fir_data_in_31_ FE_OFN470_n4676
+ fifo_from_fir_fifo_cell15_sr_out[31] AO22XLTS
XU2093 n6252 FE_OFN482_n4675 FE_OFN1734_acc_fir_data_in_13_ FE_OFN468_n4676
+ fifo_from_fir_fifo_cell15_sr_out[13] AO22XLTS
XU2084 n6243 FE_OFN485_n4675 FE_OFN1680_acc_fir_data_in_22_ FE_OFN473_n4676
+ fifo_from_fir_fifo_cell15_sr_out[22] AO22XLTS
XU2083 n6242 FE_OFN482_n4675 FE_OFN1673_acc_fir_data_in_23_ FE_OFN468_n4676
+ fifo_from_fir_fifo_cell15_sr_out[23] AO22XLTS
XU2086 n6245 FE_OFN480_n4675 FE_OFN1693_acc_fir_data_in_20_ n4676
+ fifo_from_fir_fifo_cell15_sr_out[20] AO22XLTS
XU1469 n5730 FE_OFN145_n4489 FE_OFN1586_acc_fft_data_in_6_ FE_OFN130_n4490
+ fifo_from_fft_fifo_cell15_sr_out[6] AO22XLTS
XU2094 n6253 FE_OFN485_n4675 FE_OFN1737_acc_fir_data_in_12_ FE_OFN473_n4676
+ fifo_from_fir_fifo_cell15_sr_out[12] AO22XLTS
XU2092 n6251 FE_OFN485_n4675 FE_OFN1724_acc_fir_data_in_14_ FE_OFN473_n4676
+ fifo_from_fir_fifo_cell15_sr_out[14] AO22XLTS
XU2085 n6244 FE_OFN485_n4675 FE_OFN1688_acc_fir_data_in_21_ FE_OFN473_n4676
+ fifo_from_fir_fifo_cell15_sr_out[21] AO22XLTS
XU2087 n6246 FE_OFN480_n4675 FE_OFN1700_acc_fir_data_in_19_ FE_OFN466_n4676
+ fifo_from_fir_fifo_cell15_sr_out[19] AO22XLTS
XU2081 n6240 FE_OFN475_n4675 FE_OFN1664_acc_fir_data_in_25_ FE_OFN469_n4676
+ fifo_from_fir_fifo_cell15_sr_out[25] AO22XLTS
XU1468 n5729 FE_OFN142_n4489 FE_OFN1581_acc_fft_data_in_7_ n4490
+ fifo_from_fft_fifo_cell15_sr_out[7] AO22XLTS
XU2103 n6262 FE_OFN479_n4675 FE_OFN1791_acc_fir_data_in_3_ FE_OFN464_n4676
+ fifo_from_fir_fifo_cell15_sr_out[3] AO22XLTS
XU2079 n6238 FE_OFN476_n4675 FE_OFN1651_acc_fir_data_in_27_ FE_OFN467_n4676
+ fifo_from_fir_fifo_cell15_sr_out[27] AO22XLTS
XU2091 n6250 FE_OFN483_n4675 FE_OFN1719_acc_fir_data_in_15_ FE_OFN471_n4676
+ fifo_from_fir_fifo_cell15_sr_out[15] AO22XLTS
XU2095 n6254 FE_OFN484_n4675 FE_OFN1742_acc_fir_data_in_11_ FE_OFN472_n4676
+ fifo_from_fir_fifo_cell15_sr_out[11] AO22XLTS
XU2088 n6247 FE_OFN482_n4675 FE_OFN1705_acc_fir_data_in_18_ FE_OFN468_n4676
+ fifo_from_fir_fifo_cell15_sr_out[18] AO22XLTS
XU2090 n6249 FE_OFN481_n4675 FE_OFN1717_acc_fir_data_in_16_ FE_OFN466_n4676
+ fifo_from_fir_fifo_cell15_sr_out[16] AO22XLTS
XU1470 n5731 FE_OFN145_n4489 FE_OFN1591_acc_fft_data_in_5_ FE_OFN131_n4490
+ fifo_from_fft_fifo_cell15_sr_out[5] AO22XLTS
XU2078 n6237 FE_OFN477_n4675 FE_OFN1648_acc_fir_data_in_28_ FE_OFN470_n4676
+ fifo_from_fir_fifo_cell15_sr_out[28] AO22XLTS
XU2106 n6265 FE_OFN481_n4675 FE_OFN1808_acc_fir_data_in_0_ FE_OFN464_n4676
+ fifo_from_fir_fifo_cell15_sr_out[0] AO22XLTS
XU2104 n6263 FE_OFN479_n4675 FE_OFN1799_acc_fir_data_in_2_ FE_OFN463_n4676
+ fifo_from_fir_fifo_cell15_sr_out[2] AO22XLTS
XU2098 n6257 FE_OFN484_n4675 FE_OFN1760_acc_fir_data_in_8_ FE_OFN472_n4676
+ fifo_from_fir_fifo_cell15_sr_out[8] AO22XLTS
XU2077 n6236 FE_OFN477_n4675 FE_OFN1641_acc_fir_data_in_29_ FE_OFN470_n4676
+ fifo_from_fir_fifo_cell15_sr_out[29] AO22XLTS
XU2105 n6264 FE_OFN480_n4675 FE_OFN1805_acc_fir_data_in_1_ FE_OFN463_n4676
+ fifo_from_fir_fifo_cell15_sr_out[1] AO22XLTS
XU1459 n5720 FE_OFN150_n4489 FE_OFN1533_acc_fft_data_in_16_ FE_OFN138_n4490
+ fifo_from_fft_fifo_cell15_sr_out[16] AO22XLTS
XU1475 n5736 FE_OFN144_n4489 FE_OFN1623_acc_fft_data_in_0_ FE_OFN132_n4490
+ fifo_from_fft_fifo_cell15_sr_out[0] AO22XLTS
XU1453 n5714 FE_OFN147_n4489 FE_OFN1498_acc_fft_data_in_22_ FE_OFN135_n4490
+ fifo_from_fft_fifo_cell15_sr_out[22] AO22XLTS
XU1457 n5718 FE_OFN143_n4489 FE_OFN1525_acc_fft_data_in_18_ FE_OFN129_n4490
+ fifo_from_fft_fifo_cell15_sr_out[18] AO22XLTS
XU1473 n5734 FE_OFN141_n4489 FE_OFN1609_acc_fft_data_in_2_ FE_OFN133_n4490
+ fifo_from_fft_fifo_cell15_sr_out[2] AO22XLTS
XU1458 n5719 FE_OFN150_n4489 FE_OFN1529_acc_fft_data_in_17_ FE_OFN138_n4490
+ fifo_from_fft_fifo_cell15_sr_out[17] AO22XLTS
XU1452 n5713 FE_OFN145_n4489 FE_OFN1496_acc_fft_data_in_23_ FE_OFN130_n4490
+ fifo_from_fft_fifo_cell15_sr_out[23] AO22XLTS
XU1474 n5735 FE_OFN141_n4489 FE_OFN1617_acc_fft_data_in_1_ FE_OFN133_n4490
+ fifo_from_fft_fifo_cell15_sr_out[1] AO22XLTS
XU1472 n5733 FE_OFN144_n4489 FE_OFN1604_acc_fft_data_in_3_ FE_OFN132_n4490
+ fifo_from_fft_fifo_cell15_sr_out[3] AO22XLTS
XU1454 n5715 FE_OFN147_n4489 FE_OFN1509_acc_fft_data_in_21_ FE_OFN135_n4490
+ fifo_from_fft_fifo_cell15_sr_out[21] AO22XLTS
XU1456 n5717 FE_OFN143_n4489 FE_OFN1518_acc_fft_data_in_19_ FE_OFN129_n4490
+ fifo_from_fft_fifo_cell15_sr_out[19] AO22XLTS
XU1455 n5716 FE_OFN145_n4489 FE_OFN1514_acc_fft_data_in_20_ FE_OFN130_n4490
+ fifo_from_fft_fifo_cell15_sr_out[20] AO22XLTS
XU1445 n5706 FE_OFN146_n4489 FE_OFN1460_acc_fft_data_in_30_ FE_OFN134_n4490
+ fifo_from_fft_fifo_cell15_sr_out[30] AO22XLTS
XU1448 n5709 FE_OFN141_n4489 FE_OFN1474_acc_fft_data_in_27_ FE_OFN131_n4490
+ fifo_from_fft_fifo_cell15_sr_out[27] AO22XLTS
XU1461 n5722 FE_OFN150_n4489 FE_OFN1546_acc_fft_data_in_14_ FE_OFN138_n4490
+ fifo_from_fft_fifo_cell15_sr_out[14] AO22XLTS
XU1447 n5708 FE_OFN146_n4489 FE_OFN1472_acc_fft_data_in_28_ FE_OFN134_n4490
+ fifo_from_fft_fifo_cell15_sr_out[28] AO22XLTS
XU1466 n5727 FE_OFN148_n4489 FE_OFN1571_acc_fft_data_in_9_ FE_OFN136_n4490
+ fifo_from_fft_fifo_cell15_sr_out[9] AO22XLTS
XU1446 n5707 FE_OFN146_n4489 FE_OFN1464_acc_fft_data_in_29_ FE_OFN134_n4490
+ fifo_from_fft_fifo_cell15_sr_out[29] AO22XLTS
XU1450 n5711 FE_OFN140_n4489 FE_OFN1484_acc_fft_data_in_25_ FE_OFN133_n4490
+ fifo_from_fft_fifo_cell15_sr_out[25] AO22XLTS
XU1462 n5723 FE_OFN149_n4489 FE_OFN1549_acc_fft_data_in_13_ FE_OFN137_n4490
+ fifo_from_fft_fifo_cell15_sr_out[13] AO22XLTS
XU1465 n5726 FE_OFN148_n4489 FE_OFN1565_acc_fft_data_in_10_ FE_OFN136_n4490
+ fifo_from_fft_fifo_cell15_sr_out[10] AO22XLTS
XU1467 n5728 FE_OFN148_n4489 FE_OFN1579_acc_fft_data_in_8_ FE_OFN136_n4490
+ fifo_from_fft_fifo_cell15_sr_out[8] AO22XLTS
XU1451 n5712 FE_OFN140_n4489 FE_OFN1490_acc_fft_data_in_24_ FE_OFN133_n4490
+ fifo_from_fft_fifo_cell15_sr_out[24] AO22XLTS
XU1444 n5705 FE_OFN147_n4489 FE_OFN1453_acc_fft_data_in_31_ FE_OFN135_n4490
+ fifo_from_fft_fifo_cell15_sr_out[31] AO22XLTS
XU1460 n5721 FE_OFN149_n4489 FE_OFN1542_acc_fft_data_in_15_ FE_OFN137_n4490
+ fifo_from_fft_fifo_cell15_sr_out[15] AO22XLTS
XU1464 n5725 FE_OFN149_n4489 FE_OFN1559_acc_fft_data_in_11_ FE_OFN137_n4490
+ fifo_from_fft_fifo_cell15_sr_out[11] AO22XLTS
XU1463 n5724 FE_OFN150_n4489 FE_OFN1554_acc_fft_data_in_12_ FE_OFN138_n4490
+ fifo_from_fft_fifo_cell15_sr_out[12] AO22XLTS
XU1449 n5710 FE_OFN144_n4489 FE_OFN1479_acc_fft_data_in_26_ FE_OFN132_n4490
+ fifo_from_fft_fifo_cell15_sr_out[26] AO22XLTS
XU749 n5429 FE_OFN80_n3796 FE_OFN1501_acc_fft_data_in_22_ FE_OFN70_n3797
+ fifo_from_fft_fifo_cell0_sr_out[22] AO22XLTS
XU705 n5396 FE_OFN419_n3776 FE_OFN1692_acc_fir_data_in_20_ FE_OFN401_n3777
+ fifo_from_fir_fifo_cell0_sr_out[20] AO22XLTS
XU741 n5421 FE_OFN78_n3796 FE_OFN1461_acc_fft_data_in_30_ FE_OFN68_n3797
+ fifo_from_fft_fifo_cell0_sr_out[30] AO22XLTS
XU754 n5434 FE_OFN83_n3796 FE_OFN1530_acc_fft_data_in_17_ FE_OFN71_n3797
+ fifo_from_fft_fifo_cell0_sr_out[17] AO22XLTS
XU702 n5393 FE_OFN418_n3776 FE_OFN1671_acc_fir_data_in_23_ FE_OFN406_n3777
+ fifo_from_fir_fifo_cell0_sr_out[23] AO22XLTS
XU753 n5433 FE_OFN79_n3796 FE_OFN1524_acc_fft_data_in_18_ FE_OFN67_n3797
+ fifo_from_fft_fifo_cell0_sr_out[18] AO22XLTS
XU755 n5435 FE_OFN83_n3796 FE_OFN1535_acc_fft_data_in_16_ FE_OFN71_n3797
+ fifo_from_fft_fifo_cell0_sr_out[16] AO22XLTS
XU742 n5422 FE_OFN78_n3796 FE_OFN1466_acc_fft_data_in_29_ FE_OFN68_n3797
+ fifo_from_fft_fifo_cell0_sr_out[29] AO22XLTS
XU740 n5420 FE_OFN80_n3796 FE_OFN1453_acc_fft_data_in_31_ FE_OFN70_n3797
+ fifo_from_fft_fifo_cell0_sr_out[31] AO22XLTS
XU748 n5428 FE_OFN77_n3796 FE_OFN1497_acc_fft_data_in_23_ FE_OFN65_n3797
+ fifo_from_fft_fifo_cell0_sr_out[23] AO22XLTS
XU752 n5432 FE_OFN79_n3796 FE_OFN1516_acc_fft_data_in_19_ FE_OFN67_n3797
+ fifo_from_fft_fifo_cell0_sr_out[19] AO22XLTS
XU704 n5395 FE_OFN419_n3776 FE_OFN1689_acc_fir_data_in_21_ FE_OFN401_n3777
+ fifo_from_fir_fifo_cell0_sr_out[21] AO22XLTS
XU703 n5394 FE_OFN422_n3776 FE_OFN1680_acc_fir_data_in_22_ FE_OFN401_n3777
+ fifo_from_fir_fifo_cell0_sr_out[22] AO22XLTS
XU751 n5431 FE_OFN81_n3796 FE_OFN1510_acc_fft_data_in_20_ FE_OFN69_n3797
+ fifo_from_fft_fifo_cell0_sr_out[20] AO22XLTS
XU750 n5430 FE_OFN80_n3796 FE_OFN1509_acc_fft_data_in_21_ FE_OFN70_n3797
+ fifo_from_fft_fifo_cell0_sr_out[21] AO22XLTS
XU706 n5397 FE_OFN416_n3776 FE_OFN1695_acc_fir_data_in_19_ FE_OFN406_n3777
+ fifo_from_fir_fifo_cell0_sr_out[19] AO22XLTS
XU708 n5399 FE_OFN418_n3776 FE_OFN1709_acc_fir_data_in_17_ FE_OFN409_n3777
+ fifo_from_fir_fifo_cell0_sr_out[17] AO22XLTS
XU701 n5392 FE_OFN412_n3776 FE_OFN1669_acc_fir_data_in_24_ FE_OFN408_n3777
+ fifo_from_fir_fifo_cell0_sr_out[24] AO22XLTS
XU719 n5410 FE_OFN415_n3776 FE_OFN1774_acc_fir_data_in_6_ FE_OFN404_n3777
+ fifo_from_fir_fifo_cell0_sr_out[6] AO22XLTS
XU707 n5398 FE_OFN420_n3776 FE_OFN1704_acc_fir_data_in_18_ FE_OFN409_n3777
+ fifo_from_fir_fifo_cell0_sr_out[18] AO22XLTS
XU723 n5414 FE_OFN416_n3776 FE_OFN1797_acc_fir_data_in_2_ FE_OFN406_n3777
+ fifo_from_fir_fifo_cell0_sr_out[2] AO22XLTS
XU721 n5412 FE_OFN415_n3776 FE_OFN1786_acc_fir_data_in_4_ FE_OFN402_n3777
+ fifo_from_fir_fifo_cell0_sr_out[4] AO22XLTS
XU743 n5423 FE_OFN78_n3796 FE_OFN1472_acc_fft_data_in_28_ FE_OFN68_n3797
+ fifo_from_fft_fifo_cell0_sr_out[28] AO22XLTS
XU695 n5386 FE_OFN414_n3776 FE_OFN1637_acc_fir_data_in_30_ FE_OFN410_n3777
+ fifo_from_fir_fifo_cell0_sr_out[30] AO22XLTS
XU697 n5388 FE_OFN414_n3776 FE_OFN1646_acc_fir_data_in_28_ FE_OFN410_n3777
+ fifo_from_fir_fifo_cell0_sr_out[28] AO22XLTS
XU694 n5385 FE_OFN414_n3776 FE_OFN1632_acc_fir_data_in_31_ FE_OFN410_n3777
+ fifo_from_fir_fifo_cell0_sr_out[31] AO22XLTS
XU710 n5401 FE_OFN420_n3776 FE_OFN1722_acc_fir_data_in_15_ FE_OFN405_n3777
+ fifo_from_fir_fifo_cell0_sr_out[15] AO22XLTS
XU717 n5408 FE_OFN421_n3776 FE_OFN1758_acc_fir_data_in_8_ FE_OFN411_n3777
+ fifo_from_fir_fifo_cell0_sr_out[8] AO22XLTS
XU714 n5405 FE_OFN421_n3776 FE_OFN1741_acc_fir_data_in_11_ FE_OFN411_n3777
+ fifo_from_fir_fifo_cell0_sr_out[11] AO22XLTS
XU700 n5391 FE_OFN412_n3776 FE_OFN1664_acc_fir_data_in_25_ FE_OFN408_n3777
+ fifo_from_fir_fifo_cell0_sr_out[25] AO22XLTS
XU712 n5403 FE_OFN421_n3776 FE_OFN1732_acc_fir_data_in_13_ FE_OFN411_n3777
+ fifo_from_fir_fifo_cell0_sr_out[13] AO22XLTS
XU722 n5413 FE_OFN417_n3776 FE_OFN1793_acc_fir_data_in_3_ FE_OFN403_n3777
+ fifo_from_fir_fifo_cell0_sr_out[3] AO22XLTS
XU696 n5387 FE_OFN414_n3776 FE_OFN1645_acc_fir_data_in_29_ FE_OFN410_n3777
+ fifo_from_fir_fifo_cell0_sr_out[29] AO22XLTS
XU709 n5400 FE_OFN418_n3776 FE_OFN1713_acc_fir_data_in_16_ FE_OFN409_n3777
+ fifo_from_fir_fifo_cell0_sr_out[16] AO22XLTS
XU698 n5389 FE_OFN413_n3776 FE_OFN1655_acc_fir_data_in_27_ FE_OFN407_n3777
+ fifo_from_fir_fifo_cell0_sr_out[27] AO22XLTS
XU724 n5415 FE_OFN419_n3776 FE_OFN1806_acc_fir_data_in_1_ n3777
+ fifo_from_fir_fifo_cell0_sr_out[1] AO22XLTS
XU718 n5409 FE_OFN415_n3776 FE_OFN1767_acc_fir_data_in_7_ FE_OFN404_n3777
+ fifo_from_fir_fifo_cell0_sr_out[7] AO22XLTS
XU725 n5416 FE_OFN417_n3776 FE_OFN1817_acc_fir_data_in_0_ FE_OFN403_n3777
+ fifo_from_fir_fifo_cell0_sr_out[0] AO22XLTS
XU716 n5407 FE_OFN421_n3776 FE_OFN1753_acc_fir_data_in_9_ FE_OFN411_n3777
+ fifo_from_fir_fifo_cell0_sr_out[9] AO22XLTS
XU720 n5411 FE_OFN412_n3776 FE_OFN1781_acc_fir_data_in_5_ FE_OFN404_n3777
+ fifo_from_fir_fifo_cell0_sr_out[5] AO22XLTS
XU699 n5390 FE_OFN413_n3776 FE_OFN1657_acc_fir_data_in_26_ FE_OFN407_n3777
+ fifo_from_fir_fifo_cell0_sr_out[26] AO22XLTS
XU715 n5406 FE_OFN422_n3776 FE_OFN1750_acc_fir_data_in_10_ FE_OFN405_n3777
+ fifo_from_fir_fifo_cell0_sr_out[10] AO22XLTS
XU711 n5402 FE_OFN422_n3776 FE_OFN1729_acc_fir_data_in_14_ FE_OFN405_n3777
+ fifo_from_fir_fifo_cell0_sr_out[14] AO22XLTS
XU713 n5404 FE_OFN422_n3776 FE_OFN1740_acc_fir_data_in_12_ FE_OFN405_n3777
+ fifo_from_fir_fifo_cell0_sr_out[12] AO22XLTS
XU761 n5441 FE_OFN82_n3796 FE_OFN1568_acc_fft_data_in_10_ FE_OFN72_n3797
+ fifo_from_fft_fifo_cell0_sr_out[10] AO22XLTS
XU760 n5440 FE_OFN82_n3796 FE_OFN1561_acc_fft_data_in_11_ FE_OFN72_n3797
+ fifo_from_fft_fifo_cell0_sr_out[11] AO22XLTS
XU733 n3791 n3783 n3784 n9489 OAI21XLTS
XU764 n5444 FE_OFN73_n3796 FE_OFN1581_acc_fft_data_in_7_ n3797
+ fifo_from_fft_fifo_cell0_sr_out[7] AO22XLTS
XU769 n5449 FE_OFN74_n3796 FE_OFN1608_acc_fft_data_in_2_ FE_OFN63_n3797
+ fifo_from_fft_fifo_cell0_sr_out[2] AO22XLTS
XU745 n5425 FE_OFN77_n3796 FE_OFN1478_acc_fft_data_in_26_ FE_OFN64_n3797
+ fifo_from_fft_fifo_cell0_sr_out[26] AO22XLTS
XU762 n5442 FE_OFN82_n3796 FE_OFN1571_acc_fft_data_in_9_ FE_OFN72_n3797
+ fifo_from_fft_fifo_cell0_sr_out[9] AO22XLTS
XU763 n5443 FE_OFN82_n3796 FE_OFN1579_acc_fft_data_in_8_ FE_OFN72_n3797
+ fifo_from_fft_fifo_cell0_sr_out[8] AO22XLTS
XU771 n5451 FE_OFN76_n3796 FE_OFN1623_acc_fft_data_in_0_ FE_OFN66_n3797
+ fifo_from_fft_fifo_cell0_sr_out[0] AO22XLTS
XU746 n5426 FE_OFN74_n3796 FE_OFN1483_acc_fft_data_in_25_ FE_OFN63_n3797
+ fifo_from_fft_fifo_cell0_sr_out[25] AO22XLTS
XU757 n5437 FE_OFN83_n3796 FE_OFN1546_acc_fft_data_in_14_ FE_OFN71_n3797
+ fifo_from_fft_fifo_cell0_sr_out[14] AO22XLTS
XU758 n5438 FE_OFN81_n3796 FE_OFN1550_acc_fft_data_in_13_ FE_OFN69_n3797
+ fifo_from_fft_fifo_cell0_sr_out[13] AO22XLTS
XU744 n5424 FE_OFN75_n3796 FE_OFN1473_acc_fft_data_in_27_ FE_OFN66_n3797
+ fifo_from_fft_fifo_cell0_sr_out[27] AO22XLTS
XU765 n5445 FE_OFN79_n3796 FE_OFN1586_acc_fft_data_in_6_ FE_OFN67_n3797
+ fifo_from_fft_fifo_cell0_sr_out[6] AO22XLTS
XU770 n5450 FE_OFN75_n3796 FE_OFN1615_acc_fft_data_in_1_ FE_OFN64_n3797
+ fifo_from_fft_fifo_cell0_sr_out[1] AO22XLTS
XU747 n5427 FE_OFN74_n3796 FE_OFN1490_acc_fft_data_in_24_ FE_OFN63_n3797
+ fifo_from_fft_fifo_cell0_sr_out[24] AO22XLTS
XU768 n5448 FE_OFN76_n3796 FE_OFN1604_acc_fft_data_in_3_ FE_OFN66_n3797
+ fifo_from_fft_fifo_cell0_sr_out[3] AO22XLTS
XU756 n5436 FE_OFN81_n3796 FE_OFN1542_acc_fft_data_in_15_ FE_OFN69_n3797
+ fifo_from_fft_fifo_cell0_sr_out[15] AO22XLTS
XU766 n5446 FE_OFN77_n3796 FE_OFN1594_acc_fft_data_in_5_ FE_OFN65_n3797
+ fifo_from_fft_fifo_cell0_sr_out[5] AO22XLTS
XU759 n5439 FE_OFN83_n3796 FE_OFN1556_acc_fft_data_in_12_ FE_OFN71_n3797
+ fifo_from_fft_fifo_cell0_sr_out[12] AO22XLTS
XU767 n5447 FE_OFN73_n3796 FE_OFN1598_acc_fft_data_in_4_ n3797
+ fifo_from_fft_fifo_cell0_sr_out[4] AO22XLTS
XU687 n3771 n3763 n3764 n9488 OAI21XLTS
Xrouter_addr_calc_iir_read_calc_counter_count_reg[25] n8020
+ router_addr_calc_iir_read_calc_count[25] clk__L1_N0 n7087 DFFXLTS
Xrouter_addr_calc_iir_read_calc_counter_count_reg[24] n8031
+ router_addr_calc_iir_read_calc_count[24] clk__L1_N0 n7086 DFFXLTS
Xrouter_addr_calc_iir_read_calc_counter_count_reg[23] n8021
+ router_addr_calc_iir_read_calc_count[23] clk__L1_N0 n7085 DFFXLTS
Xrouter_addr_calc_iir_read_calc_counter_count_reg[22] n8032
+ router_addr_calc_iir_read_calc_count[22] clk__L1_N0 n7084 DFFXLTS
Xrouter_addr_calc_iir_read_calc_counter_count_reg[29] n8012
+ router_addr_calc_iir_read_calc_count[29] clk__L1_N0 n7083 DFFXLTS
Xrouter_addr_calc_iir_read_calc_counter_count_reg[28] n8016
+ router_addr_calc_iir_read_calc_count[28] clk__L1_N0 n7082 DFFXLTS
Xrouter_addr_calc_iir_read_calc_counter_count_reg[27] n8019
+ router_addr_calc_iir_read_calc_count[27] clk__L1_N0 n7081 DFFXLTS
Xrouter_addr_calc_iir_read_calc_counter_count_reg[26] n8030
+ router_addr_calc_iir_read_calc_count[26] clk__L1_N0 n7080 DFFXLTS
Xrouter_addr_calc_iir_read_calc_counter_count_reg[21] n8022
+ router_addr_calc_iir_read_calc_count[21] clk__L1_N0 n7079 DFFXLTS
Xrouter_addr_calc_iir_read_calc_counter_count_reg[20] n8033
+ router_addr_calc_iir_read_calc_count[20] clk__L1_N0 n7078 DFFXLTS
Xrouter_addr_calc_iir_read_calc_counter_count_reg[19] n8023
+ router_addr_calc_iir_read_calc_count[19] clk__L1_N0 n7077 DFFXLTS
Xrouter_addr_calc_iir_read_calc_counter_count_reg[18] n8034
+ router_addr_calc_iir_read_calc_count[18] clk__L1_N0 n7076 DFFXLTS
Xrouter_addr_calc_iir_read_calc_counter_count_reg[31] n8014
+ router_addr_calc_iir_read_calc_count[31] clk__L1_N0 n7075 DFFXLTS
Xrouter_addr_calc_iir_read_calc_counter_count_reg[10] n8038
+ router_addr_calc_iir_read_calc_count[10] clk__L1_N0 n7074 DFFXLTS
Xrouter_addr_calc_iir_read_calc_counter_count_reg[9] n8028
+ router_addr_calc_iir_read_calc_count[9] clk__L1_N0 n7073 DFFXLTS
Xrouter_addr_calc_iir_read_calc_counter_count_reg[8] n8039
+ router_addr_calc_iir_read_calc_count[8] clk__L1_N0 n7072 DFFXLTS
Xrouter_addr_calc_iir_read_calc_counter_count_reg[7] n8029
+ router_addr_calc_iir_read_calc_count[7] clk__L1_N0 n7071 DFFXLTS
Xrouter_addr_calc_iir_read_calc_counter_count_reg[6] n8040
+ router_addr_calc_iir_read_calc_count[6] clk__L1_N0 n7070 DFFXLTS
Xrouter_addr_calc_iir_read_calc_counter_count_reg[5] n8013
+ router_addr_calc_iir_read_calc_count[5] clk__L1_N0 n7069 DFFXLTS
Xrouter_addr_calc_iir_read_calc_counter_count_reg[4] n8017
+ router_addr_calc_iir_read_calc_count[4] clk__L1_N0 n7068 DFFXLTS
Xrouter_addr_calc_iir_read_calc_counter_count_reg[3] n8041
+ router_addr_calc_iir_read_calc_count[3] clk__L1_N0 n7067 DFFXLTS
Xrouter_addr_calc_iir_read_calc_counter_count_reg[2] n8042
+ router_addr_calc_iir_read_calc_count[2] clk__L1_N0 n7066 DFFXLTS
Xrouter_addr_calc_iir_read_calc_counter_count_reg[1] n8015
+ router_addr_calc_iir_read_calc_count[1] clk__L1_N0 n7065 DFFXLTS
Xrouter_addr_calc_iir_read_calc_counter_count_reg[0] n8018
+ router_addr_calc_iir_read_calc_count[0] clk__L1_N0 n7064 DFFXLTS
Xrouter_addr_calc_iir_read_calc_counter_count_reg[30] n8011
+ router_addr_calc_iir_read_calc_count[30] clk__L1_N0 n7063 DFFXLTS
Xrouter_addr_calc_iir_read_calc_counter_count_reg[17] n8024
+ router_addr_calc_iir_read_calc_count[17] clk__L1_N0 n7062 DFFXLTS
Xrouter_addr_calc_iir_read_calc_counter_count_reg[16] n8035
+ router_addr_calc_iir_read_calc_count[16] clk__L1_N0 n7061 DFFXLTS
Xrouter_addr_calc_iir_read_calc_counter_count_reg[15] n8025
+ router_addr_calc_iir_read_calc_count[15] clk__L1_N0 n7060 DFFXLTS
Xrouter_addr_calc_iir_read_calc_counter_count_reg[14] n8036
+ router_addr_calc_iir_read_calc_count[14] clk__L1_N0 n7059 DFFXLTS
Xrouter_addr_calc_iir_read_calc_counter_count_reg[13] n8026
+ router_addr_calc_iir_read_calc_count[13] clk__L1_N0 n7058 DFFXLTS
Xrouter_addr_calc_iir_read_calc_counter_count_reg[12] n8037
+ router_addr_calc_iir_read_calc_count[12] clk__L1_N0 n7057 DFFXLTS
Xrouter_addr_calc_iir_read_calc_counter_count_reg[11] n8027
+ router_addr_calc_iir_read_calc_count[11] clk__L1_N0 n7056 DFFXLTS
Xrouter_addr_calc_iir_write_calc_counter_count_reg[2] n7107 n7106 clk__L1_N0
+ router_addr_calc_iir_write_calc_counter_N180
+ FE_OFN1199_router_addr_calc_iir_write_calc_counter_N212 EDFFXLTS
Xrouter_addr_calc_iir_write_calc_counter_count_reg[1] n7112 n7111 clk__L1_N0
+ router_addr_calc_iir_write_calc_counter_N179 n7014 EDFFXLTS
Xrouter_addr_calc_iir_write_calc_counter_count_reg[7] n7093 n7091 clk__L1_N0
+ router_addr_calc_iir_write_calc_counter_N185
+ FE_OFN1207_router_addr_calc_iir_write_calc_counter_N212 EDFFXLTS
Xrouter_addr_calc_iir_write_calc_counter_count_reg[6] n7090 n7088 clk__L1_N0
+ router_addr_calc_iir_write_calc_counter_N184
+ FE_OFN1207_router_addr_calc_iir_write_calc_counter_N212 EDFFXLTS
Xrouter_addr_calc_iir_write_calc_counter_count_reg[5]
+ router_addr_calc_iir_write_calc_count[5] 1225 clk__L1_N0
+ router_addr_calc_iir_write_calc_counter_N183 n7014 EDFFXLTS
Xrouter_addr_calc_iir_write_calc_counter_count_reg[4] n7095 n7094 clk__L1_N0
+ router_addr_calc_iir_write_calc_counter_N182
+ FE_OFN1199_router_addr_calc_iir_write_calc_counter_N212 EDFFXLTS
Xrouter_addr_calc_iir_write_calc_counter_count_reg[8] n7099 n7097 clk__L1_N0
+ router_addr_calc_iir_write_calc_counter_N186
+ FE_OFN1204_router_addr_calc_iir_write_calc_counter_N212 EDFFXLTS
Xrouter_addr_calc_iir_write_calc_counter_count_reg[3] n7102 n7100 clk__L1_N0
+ router_addr_calc_iir_write_calc_counter_N181
+ FE_OFN1207_router_addr_calc_iir_write_calc_counter_N212 EDFFXLTS
Xrouter_addr_calc_iir_write_calc_counter_count_reg[9]
+ router_addr_calc_iir_write_calc_count[9] 1226 clk__L1_N0
+ router_addr_calc_iir_write_calc_counter_N187
+ FE_OFN1206_router_addr_calc_iir_write_calc_counter_N212 EDFFXLTS
Xrouter_addr_calc_iir_write_calc_counter_count_reg[10] n7105 n7103 clk__L1_N0
+ router_addr_calc_iir_write_calc_counter_N188
+ FE_OFN1206_router_addr_calc_iir_write_calc_counter_N212 EDFFXLTS
Xrouter_addr_calc_iir_write_calc_counter_count_reg[11] n7110 n7108 clk__L1_N0
+ router_addr_calc_iir_write_calc_counter_N189
+ FE_OFN1204_router_addr_calc_iir_write_calc_counter_N212 EDFFXLTS
Xrouter_addr_calc_iir_write_calc_counter_count_reg[12] n7116 n7114 clk__L1_N0
+ router_addr_calc_iir_write_calc_counter_N190
+ FE_OFN1203_router_addr_calc_iir_write_calc_counter_N212 EDFFXLTS
Xrouter_addr_calc_iir_write_calc_counter_count_reg[13] n7122 n7120 clk__L1_N0
+ router_addr_calc_iir_write_calc_counter_N191
+ FE_OFN1205_router_addr_calc_iir_write_calc_counter_N212 EDFFXLTS
Xrouter_addr_calc_iir_write_calc_counter_count_reg[14] n7127 n7125 clk__L1_N0
+ router_addr_calc_iir_write_calc_counter_N192
+ FE_OFN1205_router_addr_calc_iir_write_calc_counter_N212 EDFFXLTS
Xrouter_addr_calc_fir_read_calc_counter_count_reg[10] n7328 n7327 clk__L1_N0
+ router_addr_calc_fir_read_calc_counter_N188 FE_OFN1193_n7023 EDFFXLTS
Xrouter_addr_calc_fir_read_calc_counter_count_reg[8] n7333 n7332 clk__L1_N0
+ router_addr_calc_fir_read_calc_counter_N186 FE_OFN1192_n7022 EDFFXLTS
Xrouter_addr_calc_fft_write_calc_counter_count_reg[10] n7443 n7441 clk__L1_N0
+ router_addr_calc_fft_write_calc_counter_N188 FE_OFN1162_n7019 EDFFXLTS
Xrouter_addr_calc_fft_write_calc_counter_count_reg[8] n7448 n7446 clk__L1_N0
+ router_addr_calc_fft_write_calc_counter_N186 FE_OFN1161_n7019 EDFFXLTS
Xrouter_addr_calc_fir_read_calc_counter_count_reg[1] n7363 n7362 clk__L1_N0
+ router_addr_calc_fir_read_calc_counter_N179 FE_OFN1191_n7022 EDFFXLTS
Xrouter_addr_calc_fft_read_calc_counter_count_reg[10] n7567 n7565 clk__L1_N0
+ router_addr_calc_fft_read_calc_counter_N188 FE_OFN1175_n7021 EDFFXLTS
Xrouter_addr_calc_fft_read_calc_counter_count_reg[8] n7572 n7570 clk__L1_N0
+ router_addr_calc_fft_read_calc_counter_N186 FE_OFN1175_n7021 EDFFXLTS
Xrouter_addr_calc_fir_read_calc_counter_count_reg[14] n7308 n7307 clk__L1_N0
+ router_addr_calc_fir_read_calc_counter_N192 FE_OFN1194_n7023 EDFFXLTS
Xrouter_addr_calc_fir_read_calc_counter_count_reg[13] n7314 n7312 clk__L1_N0
+ router_addr_calc_fir_read_calc_counter_N191 FE_OFN1193_n7023 EDFFXLTS
Xrouter_addr_calc_fir_read_calc_counter_count_reg[12] n7319 n7317 clk__L1_N0
+ router_addr_calc_fir_read_calc_counter_N190 FE_OFN1194_n7023 EDFFXLTS
Xrouter_addr_calc_fir_read_calc_counter_count_reg[7] n7339 n7337 clk__L1_N0
+ router_addr_calc_fir_read_calc_counter_N185 FE_OFN1192_n7022 EDFFXLTS
Xrouter_addr_calc_fir_read_calc_counter_count_reg[6] n7344 n7342 clk__L1_N0
+ router_addr_calc_fir_read_calc_counter_N184 FE_OFN1192_n7022 EDFFXLTS
Xrouter_addr_calc_fir_read_calc_counter_count_reg[5]
+ router_addr_calc_fir_read_calc_count[5] 1227 clk__L1_N0
+ router_addr_calc_fir_read_calc_counter_N183 n7023 EDFFXLTS
Xrouter_addr_calc_fir_read_calc_counter_count_reg[4] n7348 n7347 clk__L1_N0
+ router_addr_calc_fir_read_calc_counter_N182 FE_OFN1191_n7022 EDFFXLTS
Xrouter_addr_calc_fir_read_calc_counter_count_reg[3] n7353 n7352 clk__L1_N0
+ router_addr_calc_fir_read_calc_counter_N181 FE_OFN1190_n7022 EDFFXLTS
Xrouter_addr_calc_fir_read_calc_counter_count_reg[2] n7358 n7357 clk__L1_N0
+ router_addr_calc_fir_read_calc_counter_N180 n7022 EDFFXLTS
Xrouter_addr_calc_fft_write_calc_counter_count_reg[14] n7423 n7421 clk__L1_N0
+ router_addr_calc_fft_write_calc_counter_N192 FE_OFN1167_n7019 EDFFXLTS
Xrouter_addr_calc_fft_write_calc_counter_count_reg[13] n7428 n7426 clk__L1_N0
+ router_addr_calc_fft_write_calc_counter_N191 FE_OFN1164_n7019 EDFFXLTS
Xrouter_addr_calc_fft_write_calc_counter_count_reg[12] n7433 n7431 clk__L1_N0
+ router_addr_calc_fft_write_calc_counter_N190 FE_OFN1164_n7019 EDFFXLTS
Xrouter_addr_calc_fft_write_calc_counter_count_reg[7] n7453 n7451 clk__L1_N0
+ router_addr_calc_fft_write_calc_counter_N185 FE_OFN1161_n7019 EDFFXLTS
Xrouter_addr_calc_fft_write_calc_counter_count_reg[1] n7482 n7481 clk__L1_N0
+ router_addr_calc_fft_write_calc_counter_N179 FE_OFN1159_n7019 EDFFXLTS
Xrouter_addr_calc_fft_write_calc_counter_count_reg[5] n7462 n7461 clk__L1_N0
+ router_addr_calc_fft_write_calc_counter_N183 n7019 EDFFXLTS
Xrouter_addr_calc_fft_write_calc_counter_count_reg[4] n7467 n7466 clk__L1_N0
+ router_addr_calc_fft_write_calc_counter_N182 FE_OFN1158_n7019 EDFFXLTS
Xrouter_addr_calc_fft_write_calc_counter_count_reg[6] n7458 n7456 clk__L1_N0
+ router_addr_calc_fft_write_calc_counter_N184 FE_OFN1158_n7019 EDFFXLTS
Xrouter_addr_calc_fft_write_calc_counter_count_reg[3] n7473 n7471 clk__L1_N0
+ router_addr_calc_fft_write_calc_counter_N181 n7019 EDFFXLTS
Xrouter_addr_calc_fft_write_calc_counter_count_reg[2] n7478 n7476 clk__L1_N0
+ router_addr_calc_fft_write_calc_counter_N180 FE_OFN1158_n7019 EDFFXLTS
Xrouter_addr_calc_fft_read_calc_counter_count_reg[1] n7601 n7600 clk__L1_N0
+ router_addr_calc_fft_read_calc_counter_N179 FE_OFN1170_n7021 EDFFXLTS
Xrouter_addr_calc_fft_read_calc_counter_count_reg[5]
+ router_addr_calc_fft_read_calc_count[5] 1228 clk__L1_N0
+ router_addr_calc_fft_read_calc_counter_N183 FE_OFN1174_n7021 EDFFXLTS
Xrouter_addr_calc_fft_read_calc_counter_count_reg[4] n7586 n7585 clk__L1_N0
+ router_addr_calc_fft_read_calc_counter_N182 FE_OFN1176_n7021 EDFFXLTS
Xrouter_addr_calc_fft_read_calc_counter_count_reg[14] n7547 n7545 clk__L1_N0
+ router_addr_calc_fft_read_calc_counter_N192 FE_OFN1178_n7021 EDFFXLTS
Xrouter_addr_calc_fft_read_calc_counter_count_reg[13] n7552 n7550 clk__L1_N0
+ router_addr_calc_fft_read_calc_counter_N191 FE_OFN1177_n7021 EDFFXLTS
Xrouter_addr_calc_fft_read_calc_counter_count_reg[12] n7557 n7555 clk__L1_N0
+ router_addr_calc_fft_read_calc_counter_N190 FE_OFN1178_n7021 EDFFXLTS
Xrouter_addr_calc_fft_read_calc_counter_count_reg[7] n7577 n7575 clk__L1_N0
+ router_addr_calc_fft_read_calc_counter_N185 FE_OFN1178_n7021 EDFFXLTS
Xrouter_addr_calc_fft_read_calc_counter_count_reg[6] n7582 n7580 clk__L1_N0
+ router_addr_calc_fft_read_calc_counter_N184 FE_OFN1176_n7021 EDFFXLTS
Xrouter_addr_calc_fft_read_calc_counter_count_reg[3] n7592 n7590 clk__L1_N0
+ router_addr_calc_fft_read_calc_counter_N181 FE_OFN1169_n7021 EDFFXLTS
Xrouter_addr_calc_fft_read_calc_counter_count_reg[2] n7597 n7595 clk__L1_N0
+ router_addr_calc_fft_read_calc_counter_N180 FE_OFN1169_n7021 EDFFXLTS
Xrouter_addr_calc_fir_write_calc_counter_count_reg[10] n7210 n7208 clk__L1_N0
+ router_addr_calc_fir_write_calc_counter_N188 FE_OFN1185_n7020 EDFFXLTS
Xrouter_addr_calc_fir_write_calc_counter_count_reg[8] n7215 n7213 clk__L1_N0
+ router_addr_calc_fir_write_calc_counter_N186 FE_OFN1185_n7020 EDFFXLTS
Xrouter_addr_calc_fir_write_calc_counter_count_reg[1] n7244 n7243 clk__L1_N0
+ router_addr_calc_fir_write_calc_counter_N179 FE_OFN1188_n7020 EDFFXLTS
Xrouter_addr_calc_fir_write_calc_counter_count_reg[14] n7190 n7188 clk__L1_N0
+ router_addr_calc_fir_write_calc_counter_N192 FE_OFN1189_n7020 EDFFXLTS
Xrouter_addr_calc_fir_write_calc_counter_count_reg[13] n7196 n7194 clk__L1_N0
+ router_addr_calc_fir_write_calc_counter_N191 FE_OFN1186_n7020 EDFFXLTS
Xrouter_addr_calc_fir_write_calc_counter_count_reg[4] n7229 n7228 clk__L1_N0
+ router_addr_calc_fir_write_calc_counter_N182 FE_OFN1182_n7020 EDFFXLTS
Xrouter_addr_calc_fir_write_calc_counter_count_reg[3] n7235 n7233 clk__L1_N0
+ router_addr_calc_fir_write_calc_counter_N181 FE_OFN1181_n7020 EDFFXLTS
Xrouter_addr_calc_fir_write_calc_counter_count_reg[2] n7240 n7238 clk__L1_N0
+ router_addr_calc_fir_write_calc_counter_N180 FE_OFN1187_n7020 EDFFXLTS
Xrouter_addr_calc_fir_write_calc_counter_count_reg[12] n7202 n7200 clk__L1_N0
+ router_addr_calc_fir_write_calc_counter_N190 FE_OFN1186_n7020 EDFFXLTS
Xrouter_addr_calc_fir_write_calc_counter_count_reg[5]
+ router_addr_calc_fir_write_calc_count[5] 1229 clk__L1_N0
+ router_addr_calc_fir_write_calc_counter_N183 FE_OFN1180_n7020 EDFFXLTS
Xrouter_addr_calc_fir_write_calc_counter_count_reg[7] n7220 n7218 clk__L1_N0
+ router_addr_calc_fir_write_calc_counter_N185 FE_OFN1182_n7020 EDFFXLTS
Xrouter_addr_calc_fir_write_calc_counter_count_reg[6] n7225 n7223 clk__L1_N0
+ router_addr_calc_fir_write_calc_counter_N184 FE_OFN1182_n7020 EDFFXLTS
Xrouter_addr_calc_fir_write_calc_counter_count_reg[15] n7184 n7182 clk__L1_N0
+ router_addr_calc_fir_write_calc_counter_N193 FE_OFN1189_n7020 EDFFXLTS
Xrouter_addr_calc_fir_read_calc_counter_count_reg[15]
+ router_addr_calc_fir_read_calc_count[15] 1230 clk__L1_N0
+ router_addr_calc_fir_read_calc_counter_N193 FE_OFN1193_n7023 EDFFXLTS
Xrouter_addr_calc_fft_write_calc_counter_count_reg[15]
+ router_addr_calc_fft_write_calc_count[15] 1231 clk__L1_N0
+ router_addr_calc_fft_write_calc_counter_N193 FE_OFN1164_n7019 EDFFXLTS
Xrouter_addr_calc_fft_read_calc_counter_count_reg[15] n7542 n7540 clk__L1_N0
+ router_addr_calc_fft_read_calc_counter_N193 FE_OFN1177_n7021 EDFFXLTS
Xrouter_addr_calc_fir_read_calc_counter_count_reg[11] n7323 n7322 clk__L1_N0
+ router_addr_calc_fir_read_calc_counter_N189 FE_OFN1192_n7022 EDFFXLTS
Xrouter_addr_calc_fir_read_calc_counter_count_reg[9]
+ router_addr_calc_fir_read_calc_count[9] 1232 clk__L1_N0
+ router_addr_calc_fir_read_calc_counter_N187 n7023 EDFFXLTS
Xrouter_addr_calc_fft_write_calc_counter_count_reg[11] n7438 n7436 clk__L1_N0
+ router_addr_calc_fft_write_calc_counter_N189 FE_OFN1162_n7019 EDFFXLTS
Xrouter_addr_calc_fft_write_calc_counter_count_reg[9]
+ router_addr_calc_fft_write_calc_count[9] 1233 clk__L1_N0
+ router_addr_calc_fft_write_calc_counter_N187 FE_OFN1162_n7019 EDFFXLTS
Xrouter_addr_calc_fft_read_calc_counter_count_reg[11] n7562 n7560 clk__L1_N0
+ router_addr_calc_fft_read_calc_counter_N189 FE_OFN1175_n7021 EDFFXLTS
Xrouter_addr_calc_fft_read_calc_counter_count_reg[9]
+ router_addr_calc_fft_read_calc_count[9] 1234 clk__L1_N0
+ router_addr_calc_fft_read_calc_counter_N187 FE_OFN1178_n7021 EDFFXLTS
Xrouter_addr_calc_iir_write_calc_counter_count_reg[15] n7133 n7131 clk__L1_N0
+ router_addr_calc_iir_write_calc_counter_N193
+ FE_OFN1203_router_addr_calc_iir_write_calc_counter_N212 EDFFXLTS
Xrouter_addr_calc_fir_write_calc_counter_count_reg[11] n7206 n7204 clk__L1_N0
+ router_addr_calc_fir_write_calc_counter_N189 FE_OFN1186_n7020 EDFFXLTS
Xrouter_addr_calc_fir_write_calc_counter_count_reg[9]
+ router_addr_calc_fir_write_calc_count[9] 1235 clk__L1_N0
+ router_addr_calc_fir_write_calc_counter_N187 FE_OFN1185_n7020 EDFFXLTS
Xrouter_addr_calc_fir_read_calc_counter_count_reg[16] n7303 n7302 clk__L1_N0
+ router_addr_calc_fir_read_calc_counter_N194 FE_OFN1194_n7023 EDFFXLTS
Xrouter_addr_calc_fir_write_calc_counter_count_reg[16]
+ router_addr_calc_fir_write_calc_count[16] 1236 clk__L1_N0
+ router_addr_calc_fir_write_calc_counter_N194 FE_OFN1189_n7020 EDFFXLTS
Xrouter_addr_calc_fft_read_calc_counter_count_reg[16]
+ router_addr_calc_fft_read_calc_count[16] 1237 clk__L1_N0
+ router_addr_calc_fft_read_calc_counter_N194 FE_OFN1177_n7021 EDFFXLTS
Xrouter_addr_calc_fft_write_calc_counter_count_reg[16] n7418 n7416 clk__L1_N0
+ router_addr_calc_fft_write_calc_counter_N194 FE_OFN1167_n7019 EDFFXLTS
Xrouter_addr_calc_fir_write_calc_counter_count_reg[17] n7178 n7176 clk__L1_N0
+ router_addr_calc_fir_write_calc_counter_N195 FE_OFN1188_n7020 EDFFXLTS
Xrouter_addr_calc_fir_read_calc_counter_count_reg[17] n7298 n7297 clk__L1_N0
+ router_addr_calc_fir_read_calc_counter_N195 FE_OFN1195_n7023 EDFFXLTS
Xrouter_addr_calc_fft_write_calc_counter_count_reg[17] n7413 n7411 clk__L1_N0
+ router_addr_calc_fft_write_calc_counter_N195 FE_OFN1167_n7019 EDFFXLTS
Xrouter_addr_calc_fft_read_calc_counter_count_reg[17] n7537 n7535 clk__L1_N0
+ router_addr_calc_fft_read_calc_counter_N195 FE_OFN1177_n7021 EDFFXLTS
Xrouter_addr_calc_iir_write_calc_counter_count_reg[17] n7139 n7137 clk__L1_N0
+ router_addr_calc_iir_write_calc_counter_N195
+ FE_OFN1205_router_addr_calc_iir_write_calc_counter_N212 EDFFXLTS
Xrouter_addr_calc_fir_write_calc_counter_count_reg[18] n7171 n7170 clk__L1_N0
+ router_addr_calc_fir_write_calc_counter_N196 FE_OFN1188_n7020 EDFFXLTS
Xrouter_addr_calc_fir_read_calc_counter_count_reg[18] n7293 n7292 clk__L1_N0
+ router_addr_calc_fir_read_calc_counter_N196 FE_OFN1195_n7023 EDFFXLTS
Xrouter_addr_calc_fft_write_calc_counter_count_reg[18] n7407 n7406 clk__L1_N0
+ router_addr_calc_fft_write_calc_counter_N196 FE_OFN1165_n7019 EDFFXLTS
Xrouter_addr_calc_fft_read_calc_counter_count_reg[18] n7531 n7530 clk__L1_N0
+ router_addr_calc_fft_read_calc_counter_N196 FE_OFN1173_n7021 EDFFXLTS
Xrouter_addr_calc_iir_write_calc_counter_count_reg[18] n7144 n7143 clk__L1_N0
+ router_addr_calc_iir_write_calc_counter_N196
+ FE_OFN1202_router_addr_calc_iir_write_calc_counter_N212 EDFFXLTS
Xrouter_addr_calc_fir_write_calc_counter_count_reg[19]
+ router_addr_calc_fir_write_calc_count[19] 1238 clk__L1_N0
+ router_addr_calc_fir_write_calc_counter_N197 FE_OFN1189_n7020 EDFFXLTS
Xrouter_addr_calc_fir_read_calc_counter_count_reg[19]
+ router_addr_calc_fir_read_calc_count[19] 1239 clk__L1_N0
+ router_addr_calc_fir_read_calc_counter_N197 FE_OFN1198_n7023 EDFFXLTS
Xrouter_addr_calc_fft_write_calc_counter_count_reg[19]
+ router_addr_calc_fft_write_calc_count[19] 1240 clk__L1_N0
+ router_addr_calc_fft_write_calc_counter_N197 FE_OFN1165_n7019 EDFFXLTS
Xrouter_addr_calc_fft_read_calc_counter_count_reg[19]
+ router_addr_calc_fft_read_calc_count[19] 1241 clk__L1_N0
+ router_addr_calc_fft_read_calc_counter_N197 FE_OFN1173_n7021 EDFFXLTS
Xrouter_addr_calc_iir_write_calc_counter_count_reg[20] n7150 n7149 clk__L1_N0
+ router_addr_calc_iir_write_calc_counter_N198
+ FE_OFN1202_router_addr_calc_iir_write_calc_counter_N212 EDFFXLTS
Xrouter_addr_calc_fft_read_calc_counter_count_reg[20] n7526 n7525 clk__L1_N0
+ router_addr_calc_fft_read_calc_counter_N198 FE_OFN1173_n7021 EDFFXLTS
Xrouter_addr_calc_fir_write_calc_counter_count_reg[20] n7165 n7164 clk__L1_N0
+ router_addr_calc_fir_write_calc_counter_N198 FE_OFN1188_n7020 EDFFXLTS
Xrouter_addr_calc_fir_read_calc_counter_count_reg[20] n7288 n7287 clk__L1_N0
+ router_addr_calc_fir_read_calc_counter_N198 FE_OFN1196_n7023 EDFFXLTS
Xrouter_addr_calc_fft_write_calc_counter_count_reg[20] n7402 n7401 clk__L1_N0
+ router_addr_calc_fft_write_calc_counter_N198 FE_OFN1165_n7019 EDFFXLTS
Xrouter_addr_calc_fir_write_calc_counter_count_reg[21] n7159 n7158 clk__L1_N0
+ router_addr_calc_fir_write_calc_counter_N199 FE_OFN1184_n7020 EDFFXLTS
Xrouter_addr_calc_fir_read_calc_counter_count_reg[21] n7283 n7282 clk__L1_N0
+ router_addr_calc_fir_read_calc_counter_N199 FE_OFN1198_n7023 EDFFXLTS
Xrouter_addr_calc_fft_write_calc_counter_count_reg[21] n7397 n7396 clk__L1_N0
+ router_addr_calc_fft_write_calc_counter_N199 FE_OFN1165_n7019 EDFFXLTS
Xrouter_addr_calc_fft_read_calc_counter_count_reg[21] n7521 n7520 clk__L1_N0
+ router_addr_calc_fft_read_calc_counter_N199 FE_OFN1173_n7021 EDFFXLTS
Xrouter_addr_calc_iir_write_calc_counter_count_reg[21] n7156 n7155 clk__L1_N0
+ router_addr_calc_iir_write_calc_counter_N199
+ FE_OFN1200_router_addr_calc_iir_write_calc_counter_N212 EDFFXLTS
Xrouter_addr_calc_iir_write_calc_counter_count_reg[22] n7163 n7161 clk__L1_N0
+ router_addr_calc_iir_write_calc_counter_N200
+ FE_OFN1200_router_addr_calc_iir_write_calc_counter_N212 EDFFXLTS
Xrouter_addr_calc_fft_read_calc_counter_count_reg[22] n7516 n7515 clk__L1_N0
+ router_addr_calc_fft_read_calc_counter_N200 FE_OFN1172_n7021 EDFFXLTS
Xrouter_addr_calc_fir_write_calc_counter_count_reg[22] n7153 n7152 clk__L1_N0
+ router_addr_calc_fir_write_calc_counter_N200 FE_OFN1187_n7020 EDFFXLTS
Xrouter_addr_calc_fir_read_calc_counter_count_reg[22] n7278 n7277 clk__L1_N0
+ router_addr_calc_fir_read_calc_counter_N200 FE_OFN1196_n7023 EDFFXLTS
Xrouter_addr_calc_fft_write_calc_counter_count_reg[22] n7392 n7391 clk__L1_N0
+ router_addr_calc_fft_write_calc_counter_N200 FE_OFN1160_n7019 EDFFXLTS
Xrouter_addr_calc_fir_write_calc_counter_count_reg[23]
+ router_addr_calc_fir_write_calc_count[23] 1242 clk__L1_N0
+ router_addr_calc_fir_write_calc_counter_N201 FE_OFN1184_n7020 EDFFXLTS
Xrouter_addr_calc_fir_read_calc_counter_count_reg[23]
+ router_addr_calc_fir_read_calc_count[23] 1243 clk__L1_N0
+ router_addr_calc_fir_read_calc_counter_N201 FE_OFN1198_n7023 EDFFXLTS
Xrouter_addr_calc_fft_write_calc_counter_count_reg[23]
+ router_addr_calc_fft_write_calc_count[23] 1244 clk__L1_N0
+ router_addr_calc_fft_write_calc_counter_N201 FE_OFN1163_n7019 EDFFXLTS
Xrouter_addr_calc_fft_read_calc_counter_count_reg[23]
+ router_addr_calc_fft_read_calc_count[23] 1245 clk__L1_N0
+ router_addr_calc_fft_read_calc_counter_N201 FE_OFN1171_n7021 EDFFXLTS
Xrouter_addr_calc_iir_write_calc_counter_count_reg[23]
+ router_addr_calc_iir_write_calc_count[23] 1246 clk__L1_N0
+ router_addr_calc_iir_write_calc_counter_N201
+ FE_OFN1201_router_addr_calc_iir_write_calc_counter_N212 EDFFXLTS
Xrouter_addr_calc_fir_write_calc_counter_count_reg[24] n7148 n7146 clk__L1_N0
+ router_addr_calc_fir_write_calc_counter_N202 FE_OFN1184_n7020 EDFFXLTS
Xrouter_addr_calc_fir_read_calc_counter_count_reg[24] n7273 n7272 clk__L1_N0
+ router_addr_calc_fir_read_calc_counter_N202 FE_OFN1198_n7023 EDFFXLTS
Xrouter_addr_calc_fft_write_calc_counter_count_reg[24] n7388 n7386 clk__L1_N0
+ router_addr_calc_fft_write_calc_counter_N202 FE_OFN1160_n7019 EDFFXLTS
Xrouter_addr_calc_fft_read_calc_counter_count_reg[24] n7512 n7510 clk__L1_N0
+ router_addr_calc_fft_read_calc_counter_N202 FE_OFN1171_n7021 EDFFXLTS
Xrouter_addr_calc_iir_write_calc_counter_count_reg[24] n7169 n7167 clk__L1_N0
+ router_addr_calc_iir_write_calc_counter_N202
+ FE_OFN1201_router_addr_calc_iir_write_calc_counter_N212 EDFFXLTS
Xrouter_addr_calc_fir_write_calc_counter_count_reg[25] n7142 n7140 clk__L1_N0
+ router_addr_calc_fir_write_calc_counter_N203 FE_OFN1183_n7020 EDFFXLTS
Xrouter_addr_calc_fir_read_calc_counter_count_reg[25] n7268 n7267 clk__L1_N0
+ router_addr_calc_fir_read_calc_counter_N203 FE_OFN1196_n7023 EDFFXLTS
Xrouter_addr_calc_fft_write_calc_counter_count_reg[25] n7383 n7381 clk__L1_N0
+ router_addr_calc_fft_write_calc_counter_N203 FE_OFN1163_n7019 EDFFXLTS
Xrouter_addr_calc_fft_read_calc_counter_count_reg[25] n7507 n7505 clk__L1_N0
+ router_addr_calc_fft_read_calc_counter_N203 FE_OFN1172_n7021 EDFFXLTS
Xrouter_addr_calc_iir_write_calc_counter_count_reg[25] n7175 n7173 clk__L1_N0
+ router_addr_calc_iir_write_calc_counter_N203
+ FE_OFN1204_router_addr_calc_iir_write_calc_counter_N212 EDFFXLTS
Xrouter_addr_calc_fir_write_calc_counter_count_reg[26] n7135 n7134 clk__L1_N0
+ router_addr_calc_fir_write_calc_counter_N204 FE_OFN1183_n7020 EDFFXLTS
Xrouter_addr_calc_fir_read_calc_counter_count_reg[26] n7264 n7262 clk__L1_N0
+ router_addr_calc_fir_read_calc_counter_N204 FE_OFN1197_n7023 EDFFXLTS
Xrouter_addr_calc_fft_write_calc_counter_count_reg[26] n7377 n7376 clk__L1_N0
+ router_addr_calc_fft_write_calc_counter_N204 FE_OFN1166_n7019 EDFFXLTS
Xrouter_addr_calc_fft_read_calc_counter_count_reg[26] n7501 n7500 clk__L1_N0
+ router_addr_calc_fft_read_calc_counter_N204 FE_OFN1174_n7021 EDFFXLTS
Xrouter_addr_calc_iir_write_calc_counter_count_reg[26] n7181 n7179 clk__L1_N0
+ router_addr_calc_iir_write_calc_counter_N204
+ FE_OFN1200_router_addr_calc_iir_write_calc_counter_N212 EDFFXLTS
Xrouter_addr_calc_fir_write_calc_counter_count_reg[27]
+ router_addr_calc_fir_write_calc_count[27] 1247 clk__L1_N0
+ router_addr_calc_fir_write_calc_counter_N205 FE_OFN1181_n7020 EDFFXLTS
Xrouter_addr_calc_fir_read_calc_counter_count_reg[27]
+ router_addr_calc_fir_read_calc_count[27] 1248 clk__L1_N0
+ router_addr_calc_fir_read_calc_counter_N205 FE_OFN1191_n7022 EDFFXLTS
Xrouter_addr_calc_fft_write_calc_counter_count_reg[27]
+ router_addr_calc_fft_write_calc_count[27] 1249 clk__L1_N0
+ router_addr_calc_fft_write_calc_counter_N205 FE_OFN1166_n7019 EDFFXLTS
Xrouter_addr_calc_fft_read_calc_counter_count_reg[27]
+ router_addr_calc_fft_read_calc_count[27] 1250 clk__L1_N0
+ router_addr_calc_fft_read_calc_counter_N205 FE_OFN1171_n7021 EDFFXLTS
Xrouter_addr_calc_fir_write_calc_counter_count_reg[28] n7129 n7128 clk__L1_N0
+ router_addr_calc_fir_write_calc_counter_N206 FE_OFN1181_n7020 EDFFXLTS
Xrouter_addr_calc_fir_read_calc_counter_count_reg[28] n7259 n7257 clk__L1_N0
+ router_addr_calc_fir_read_calc_counter_N206 FE_OFN1197_n7023 EDFFXLTS
Xrouter_addr_calc_fft_write_calc_counter_count_reg[28] n7372 n7371 clk__L1_N0
+ router_addr_calc_fft_write_calc_counter_N206 FE_OFN1160_n7019 EDFFXLTS
Xrouter_addr_calc_fft_read_calc_counter_count_reg[28] n7496 n7495 clk__L1_N0
+ router_addr_calc_fft_read_calc_counter_N206 FE_OFN1170_n7021 EDFFXLTS
Xrouter_addr_calc_iir_write_calc_counter_count_reg[28] n7187 n7185 clk__L1_N0
+ router_addr_calc_iir_write_calc_counter_N206
+ router_addr_calc_iir_write_calc_counter_N212 EDFFXLTS
Xrouter_addr_calc_fir_write_calc_counter_count_reg[29] n7124 n7123 clk__L1_N0
+ router_addr_calc_fir_write_calc_counter_N207 FE_OFN1179_n7020 EDFFXLTS
Xrouter_addr_calc_fir_read_calc_counter_count_reg[29] n7254 n7253 clk__L1_N0
+ router_addr_calc_fir_read_calc_counter_N207 FE_OFN1197_n7023 EDFFXLTS
Xrouter_addr_calc_fft_read_calc_counter_count_reg[29] n7492 n7491 clk__L1_N0
+ router_addr_calc_fft_read_calc_counter_N207 FE_OFN1168_n7021 EDFFXLTS
Xrouter_addr_calc_iir_write_calc_counter_count_reg[29] n7193 n7191 clk__L1_N0
+ router_addr_calc_iir_write_calc_counter_N207
+ router_addr_calc_iir_write_calc_counter_N212 EDFFXLTS
Xrouter_addr_calc_fft_write_calc_counter_count_reg[29]
+ router_addr_calc_fft_write_calc_count[29] 1251 clk__L1_N0
+ router_addr_calc_fft_write_calc_counter_N207 FE_OFN1166_n7019 EDFFXLTS
Xrouter_addr_calc_fft_write_calc_counter_count_reg[30] n7368 n7367 clk__L1_N0
+ router_addr_calc_fft_write_calc_counter_N208 FE_OFN1159_n7019 EDFFXLTS
Xrouter_addr_calc_fir_write_calc_counter_count_reg[30]
+ router_addr_calc_fir_write_calc_count[30] 1252 clk__L1_N0
+ router_addr_calc_fir_write_calc_counter_N208 FE_OFN1179_n7020 EDFFXLTS
Xrouter_addr_calc_fir_read_calc_counter_count_reg[30]
+ router_addr_calc_fir_read_calc_count[30] 1253 clk__L1_N0
+ router_addr_calc_fir_read_calc_counter_N208 n7022 EDFFXLTS
Xrouter_addr_calc_fft_read_calc_counter_count_reg[30]
+ router_addr_calc_fft_read_calc_count[30] 1254 clk__L1_N0
+ router_addr_calc_fft_read_calc_counter_N208 FE_OFN1168_n7021 EDFFXLTS
Xrouter_addr_calc_fft_write_calc_counter_count_reg[31]
+ router_addr_calc_fft_write_calc_count[31] 1255 clk__L1_N0
+ router_addr_calc_fft_write_calc_counter_N209 FE_OFN1166_n7019 EDFFXLTS
Xrouter_addr_calc_iir_write_calc_counter_count_reg[31] n7198 n7197 clk__L1_N0
+ router_addr_calc_iir_write_calc_counter_N209 n7014 EDFFXLTS
Xrouter_addr_calc_fir_read_calc_counter_count_reg[31] n7249 n7248 clk__L1_N0
+ router_addr_calc_fir_read_calc_counter_N209 FE_OFN1191_n7022 EDFFXLTS
Xrouter_addr_calc_fir_write_calc_counter_count_reg[31] n7118 n7117 clk__L1_N0
+ router_addr_calc_fir_write_calc_counter_N209 FE_OFN1180_n7020 EDFFXLTS
Xrouter_addr_calc_fft_read_calc_counter_count_reg[31] n7487 n7486 clk__L1_N0
+ router_addr_calc_fft_read_calc_counter_N209 FE_OFN1176_n7021 EDFFXLTS
Xrouter_addr_calc_from_fft_go_reg n8063 router_addr_calc_N63 clk__L1_N0 n5462
+ DFFXLTS
Xrouter_addr_calc_to_fft_go_reg n8064 router_addr_calc_N9 clk__L1_N0 n5463
+ DFFXLTS
Xfifo_from_fir_empty_det_result_reg from_fir_empty n3467 clk__L1_N0
+ fifo_from_fir_empty_det_N4 DFFXLTS
Xfifo_from_fft_empty_det_result_reg from_fft_empty n3478 clk__L1_N0
+ fifo_from_fft_empty_det_N4 DFFXLTS
Xrouter_addr_calc_from_fir_go_reg n8061 router_addr_calc_N99 clk__L1_N0 n5465
+ DFFXLTS
Xrouter_addr_calc_to_fir_go_reg n8062 router_addr_calc_N95 clk__L1_N0 n5464
+ DFFXLTS
Xfifo_to_fir_fifo_cell0_reg_ptok_out_valid_put_reg
+ fifo_to_fir_fifo_cell0_reg_ptok_out_valid_put n3800 clk__L1_N0 n5453 DFFXLTS
Xfifo_to_fft_fifo_cell0_reg_ptok_out_valid_put_reg
+ fifo_to_fft_fifo_cell0_reg_ptok_out_valid_put n3811 clk__L1_N0 n5455 DFFXLTS
Xfifo_from_fir_fifo_cell0_reg_ptok_out_valid_put_reg
+ fifo_from_fir_fifo_cell0_reg_ptok_out_valid_put n3760 clk__L1_N0 n5383
+ DFFXLTS
Xfifo_from_fft_fifo_cell0_reg_ptok_out_valid_put_reg
+ fifo_from_fft_fifo_cell0_reg_ptok_out_valid_put n3780 clk__L1_N0 n5418
+ DFFXLTS
Xrouter_addr_calc_iir_read_calc_counter_done_reg n3710 clk__L1_N0
+ router_addr_calc_iir_read_calc_counter_N40 n9390 VDD SDFFQXLTS
XU3895 n8055 n8872 n4793 n4794 OR3X1TS
XU3898 n8784 n8057 INVX2TS
XU3899 n8805 FE_OFN730_n8058 INVX2TS
XU3900 n4112 n8784 n4169 n4170 OR3X1TS
XU3901 n3937 n8805 n3994 n3995 OR3X1TS
XU3902 n8785 FE_OFN734_n8057 INVX2TS
XU3903 n8806 FE_OFN731_n8058 INVX2TS
XU3904 n4097 n8785 n4160 n4161 OR3X1TS
XU3905 n3922 n8806 n3985 n3986 OR3X1TS
XU3906 n8786 FE_OFN734_n8057 INVX2TS
XU3907 n4092 n8785 n4157 n4158 OR3X1TS
XU3908 n8807 FE_OFN731_n8058 INVX2TS
XU3909 n3917 n8806 n3982 n3983 OR3X1TS
XU3910 n4072 n8786 n4145 n4146 OR3X1TS
XU3911 n4077 n8786 n4148 n4149 OR3X1TS
XU3912 n3897 n8807 n3970 n3971 OR3X1TS
XU3913 n3902 n8807 n3973 n3974 OR3X1TS
XU3914 n3907 n8807 n3976 n3977 NOR3X1TS
XU3915 n3932 n8806 n3991 n3992 NOR3X1TS
XU3916 n3892 n8808 n3967 n3968 NOR3X1TS
XU3917 n4082 n8786 n4151 n4152 NOR3X1TS
XU3918 n4107 n8785 n4166 n4167 NOR3X1TS
XU3919 n4067 n8787 n4142 n4143 NOR3X1TS
XU3923 n4062 n8787 n4139 n4140 NOR3X1TS
XU3924 n3887 n8808 n3964 n3965 NOR3X1TS
XU3926 n7972 FE_OFN797_n7619 FE_OFN700_n3959 OR2X2TS
XU3929 n8054 n8839 n4607 n4608 OR3X1TS
XU3944 n8053 n8870 n4826 n4827 OR3X1TS
XU3945 n3772 fifo_from_fir_hang[14] n4674 n3764 AOI21X1TS
XU3949 n4181 n4184 n4055 n3804 AOI2BB1X1TS
XU3951 n4006 n4009 n3880 n3815 AOI2BB1X1TS
XU3984 add_x_22_0_carry[31] router_addr_calc_fft_read_calc_counter_N76
+ FE_OFN1229_router_addr_calc_fft_read_calc_count_30_ add_x_22_0_carry[30]
+ ADDHXLTS
XU3985 add_x_22_2_carry[31] router_addr_calc_fir_read_calc_counter_N76
+ FE_OFN1230_router_addr_calc_fir_read_calc_count_30_ add_x_22_2_carry[30]
+ ADDHXLTS
XU3986 add_x_22_3_carry[31] router_addr_calc_fir_write_calc_counter_N76
+ router_addr_calc_fir_write_calc_count[30] add_x_22_3_carry[30] ADDHXLTS
XU3987 add_x_22_5_carry[30] router_addr_calc_iir_write_calc_counter_N75 n7193
+ add_x_22_5_carry[29] ADDHXLTS
XU3988 add_x_22_5_carry[29] router_addr_calc_iir_write_calc_counter_N74 n7187
+ add_x_22_5_carry[28] ADDHXLTS
XU3989 add_x_22_0_carry[29] router_addr_calc_fft_read_calc_counter_N74 n7497
+ add_x_22_0_carry[28] ADDHXLTS
XU3992 add_x_22_1_carry[29] router_addr_calc_fft_write_calc_counter_N74 n7373
+ add_x_22_1_carry[28] ADDHXLTS
XU3995 add_x_22_2_carry[29] router_addr_calc_fir_read_calc_counter_N74
+ FE_OFN1236_n7259 add_x_22_2_carry[28] ADDHXLTS
XU3998 add_x_22_3_carry[29] router_addr_calc_fir_write_calc_counter_N74 n7130
+ add_x_22_3_carry[28] ADDHXLTS
XU4020 n9412 FE_OFN989_n9431 INVX2TS
XU4027 n9411 FE_OFN989_n9431 INVX2TS
XU4032 n3530 router_data_from_fir router_addr_calc_fir_write_calc_counter_N40
+ NAND2X1TS
XU4033 n3662 router_data_to_fft router_addr_calc_fft_read_calc_counter_N40
+ NAND2X1TS
XU4034 n3618 FE_OFN1438_router_data_from_fft
+ router_addr_calc_fft_write_calc_counter_N40 NAND2X1TS
XU4035 n3574 router_data_to_fir router_addr_calc_fir_read_calc_counter_N40
+ NAND2X1TS
XU4044 add_x_22_3_carry[2] router_addr_calc_fir_write_calc_counter_N47 n7244
+ FE_OFN1445_router_addr_calc_fir_write_calc_count_0_ ADDHXLTS
XU4050 add_x_22_0_carry[2] router_addr_calc_fft_read_calc_counter_N47 n7601
+ FE_OFN1444_router_addr_calc_fft_read_calc_count_0_ ADDHXLTS
XU4052 add_x_22_1_carry[2] router_addr_calc_fft_write_calc_counter_N47 n7482
+ FE_OFN1443_router_addr_calc_fft_write_calc_count_0_ ADDHXLTS
XU4061 add_x_22_2_carry[2] router_addr_calc_fir_read_calc_counter_N47 n7363
+ router_addr_calc_fir_read_calc_count[0] ADDHXLTS
XU4062 n9408 FE_OFN985_n9431 INVX2TS
XU4064 n9409 FE_OFN989_n9431 INVX2TS
XU4066 n9410 FE_OFN987_n9431 INVX2TS
XU4076 n9384 FE_OFN1289_iir_enable INVX2TS
XU4077 n9385 FE_OFN1289_iir_enable INVX2TS
XU4078 n9382 FE_OFN1287_iir_enable INVX2TS
XU4079 n9383 FE_OFN1288_iir_enable INVX2TS
XU4080 n9381 FE_OFN1287_iir_enable INVX2TS
XU4081 n9386 FE_OFN1289_iir_enable INVX2TS
XU4082 n9388 FE_OFN1287_iir_enable INVX2TS
XU4083 n9387 FE_OFN1289_iir_enable INVX2TS
XU4090 n4207 n3456 INVX2TS
XU4093 n9513 FE_OFN821_n7619 INVX2TS
XU4096 n3846 n4841 n3455 NAND2X1TS
XU4097 n3756 n3843 router_data_from_fir n3828 NAND3X1TS
XU4098 n4638 n4462 INVX2TS
XU4099 n4824 n4648 INVX2TS
XU4102 n4080 n7380 n4078 n4082 OAI21X1TS
XU4104 n4065 n7356 n4063 n4067 OAI21X1TS
XU4108 n4130 n7450 n7444 n4132 OAI21X1TS
XU4110 n3955 n7341 n7335 n3957 OAI21X1TS
XU4113 n3905 n7271 n3903 n3907 OAI21X1TS
XU4114 n3890 n7247 n3888 n3892 OAI21X1TS
XU4117 n4026 n5206 fifo_to_fir_hold[1] OR2X2TS
XU4118 n5206 n7450 fifo_to_fir_fifo_cell1_controller_write_enable
+ fifo_to_fir_fifo_cell1_controller_valid_read n5207 NOR4XLTS
XU4119 n3851 n5248 fifo_to_fft_hold[1] OR2X2TS
XU4120 n5248 n7341 fifo_to_fft_fifo_cell1_controller_write_enable
+ fifo_to_fft_fifo_cell1_controller_valid_read n5249 NOR4XLTS
XU4122 n4032 n4122 fifo_to_fir_fifo_cell3_data_out_N35 n5203
+ fifo_to_fir_hold[3] AOI31X1TS
XU4123 n4122 n8784 n4175 n4176 NOR3X1TS
XU4124 n4173 n4032 INVX2TS
XU4126 n3947 n8805 n4000 n4001 NOR3X1TS
XU4127 n3998 n3857 INVX2TS
XU4128 n4034 n4117 fifo_to_fir_fifo_cell4_data_out_N35 n5202
+ fifo_to_fir_hold[4] AOI31X1TS
XU4129 n4117 n8784 n4172 n4173 NOR3X1TS
XU4130 n3859 n3942 fifo_to_fft_fifo_cell4_data_out_N35 n5244
+ fifo_to_fft_hold[4] AOI31X1TS
XU4131 n3942 n8805 n3997 n3998 NOR3X1TS
XU4132 n3861 n7315 fifo_to_fft_fifo_cell5_data_out_N35 n5243
+ fifo_to_fft_hold[5] AOI31X1TS
XU4133 n5243 n7311 fifo_to_fft_fifo_cell5_controller_write_enable
+ fifo_to_fft_fifo_cell5_controller_valid_read NOR3X1TS
XU4134 n4040 n4102 fifo_to_fir_fifo_cell7_data_out_N35 n5199
+ fifo_to_fir_hold[7] AOI31X1TS
XU4135 n5199 n7410 fifo_to_fir_fifo_cell7_controller_write_enable
+ fifo_to_fir_fifo_cell7_controller_valid_read NOR3X1TS
XU4136 n4102 n8785 n4163 n4164 NOR3X1TS
XU4137 n3927 n8806 n3988 n3989 NOR3X1TS
XU4138 n4042 n7404 fifo_to_fir_fifo_cell8_data_out_N35 n5198
+ fifo_to_fir_hold[8] AOI31X1TS
XU4139 n5198 n7400 fifo_to_fir_fifo_cell8_controller_write_enable
+ fifo_to_fir_fifo_cell8_controller_valid_read NOR3X1TS
XU4140 n3867 FE_OFN678_n7295 fifo_to_fft_fifo_cell8_data_out_N35 n5240
+ fifo_to_fft_hold[8] AOI31X1TS
XU4141 n5240 n7291 fifo_to_fft_fifo_cell8_controller_write_enable
+ fifo_to_fft_fifo_cell8_controller_valid_read NOR3X1TS
XU4142 n4046 n4087 fifo_to_fir_fifo_cell10_data_out_N35 n5196
+ fifo_to_fir_hold[10] AOI31X1TS
XU4143 n5196 n7385 fifo_to_fir_fifo_cell10_controller_write_enable
+ fifo_to_fir_fifo_cell10_controller_valid_read NOR3X1TS
XU4144 n4087 n8786 n4154 n4155 NOR3X1TS
XU4145 n4044 n7394 fifo_to_fir_fifo_cell9_data_out_N35 n5197
+ fifo_to_fir_hold[9] AOI31X1TS
XU4146 n5197 n7390 fifo_to_fir_fifo_cell9_controller_write_enable
+ fifo_to_fir_fifo_cell9_controller_valid_read NOR3X1TS
XU4147 n3912 n8807 n3979 n3980 NOR3X1TS
XU4149 n4052 fifo_to_fir_fifo_cell13_data_out_N35 n7365 n5193
+ fifo_to_fir_hold[13] AOI31X1TS
XU4150 n3757 router_data_from_iir n4644 NOR2BX1TS
XU4151 n4456 instruction[2] n3848 NAND2X1TS
XU4153 n3839 router_data_cntl_fir_full_flag n7609 n3838 AO21X1TS
XU4165 n3720 n3756 n3757 n3758 NOR3BX1TS
XU4192 n3458 instruction[30] instruction[31] NAND2X1TS
XU4193 n3794 fifo_from_fft_fifo_cell0_controller_f_i_get
+ fifo_from_fft_fifo_cell0_controller_f_i_put n9497 OA21XLTS
XU4194 n3774 fifo_from_fir_fifo_cell0_controller_f_i_get
+ fifo_from_fir_fifo_cell0_controller_f_i_put n9484 OA21XLTS
XU4236 n4507 n8839 n4610 n4611 NOR3X1TS
XU4241 n4508 FE_OFN844_n7619 FE_OFN176_n4507 NOR2X1TS
XU4256 n4513 n8839 n4613 n4614 NOR3X1TS
XU4273 n4519 n8839 n4616 n4617 NOR3X1TS
XU4284 n4525 n8838 n4619 n4620 NOR3X1TS
XU4454 n4693 n8872 n4796 n4797 NOR3X1TS
XU4459 n4694 FE_OFN846_n7619 FE_OFN518_n4693 NOR2X1TS
XU4474 n4699 n8872 n4799 n4800 NOR3X1TS
XU4491 n4705 n8872 n4802 n4803 NOR3X1TS
XU4501 n4711 n8871 n4805 n4806 NOR3X1TS
XU4520 n4718 FE_OFN837_n7619 FE_OFN571_n4717 NOR2X1TS
XU4553 n4730 FE_OFN845_n7619 FE_OFN608_n4729 NOR2X1TS
XU4568 n4735 n8870 n4817 n4818 NOR3X1TS
XU4583 n4741 n8870 n4820 n4821 NOR3X1TS
XU4600 n4747 n8870 n4823 n4824 NOR3X1TS
XU4640 n3776 n3772 n8877 NOR2X1TS
XU4643 n9433 FE_OFN979_n9462 INVX2TS
XU4647 add_x_22_5_carry[31] router_addr_calc_iir_write_calc_counter_N76
+ router_addr_calc_iir_write_calc_count[30] add_x_22_5_carry[30] ADDHXLTS
XU4660 n4492 fifo_from_fft_fifo_cell15_controller_f_i_get
+ fifo_from_fft_fifo_cell15_controller_f_i_put n9483 OA21XLTS
XU4661 n4498 fifo_from_fft_fifo_cell14_controller_f_i_get
+ fifo_from_fft_fifo_cell14_controller_f_i_put n9483 OA21XLTS
XU4662 n4504 fifo_from_fft_fifo_cell13_controller_f_i_get
+ fifo_from_fft_fifo_cell13_controller_f_i_put n9483 OA21XLTS
XU4663 n4510 fifo_from_fft_fifo_cell12_controller_f_i_get
+ fifo_from_fft_fifo_cell12_controller_f_i_put n9483 OA21XLTS
XU4664 n4534 fifo_from_fft_fifo_cell8_controller_f_i_get
+ fifo_from_fft_fifo_cell8_controller_f_i_put n9482 OA21XLTS
XU4665 n4540 fifo_from_fft_fifo_cell7_controller_f_i_get
+ fifo_from_fft_fifo_cell7_controller_f_i_put n9481 OA21XLTS
XU4666 n4546 fifo_from_fft_fifo_cell6_controller_f_i_get
+ fifo_from_fft_fifo_cell6_controller_f_i_put n9481 OA21XLTS
XU4667 n4552 fifo_from_fft_fifo_cell5_controller_f_i_get
+ fifo_from_fft_fifo_cell5_controller_f_i_put n9481 OA21XLTS
XU4668 n4564 fifo_from_fft_fifo_cell3_controller_f_i_get
+ fifo_from_fft_fifo_cell3_controller_f_i_put n9481 OA21XLTS
XU4669 n4570 fifo_from_fft_fifo_cell2_controller_f_i_get
+ fifo_from_fft_fifo_cell2_controller_f_i_put n9497 OA21XLTS
XU4670 n4572 FE_OFN721_n4643 fifo_from_fft_fifo_cell1_reg_gtok_token NAND2X1TS
XU4671 n4566 FE_OFN719_n4643 fifo_from_fft_fifo_cell2_reg_gtok_token NAND2X1TS
XU4672 n4560 n4643 fifo_from_fft_fifo_cell3_reg_gtok_token NAND2X1TS
XU4673 n4554 FE_OFN1823_n4643 fifo_from_fft_fifo_cell4_reg_gtok_token NAND2X1TS
XU4674 n4548 FE_OFN720_n4643 fifo_from_fft_fifo_cell5_reg_gtok_token NAND2X1TS
XU4675 n4542 FE_OFN723_n4643 fifo_from_fft_fifo_cell6_reg_gtok_token NAND2X1TS
XU4676 n4536 FE_OFN727_n4643 fifo_from_fft_fifo_cell7_reg_gtok_token NAND2X1TS
XU4677 n4530 FE_OFN727_n4643 fifo_from_fft_fifo_cell8_reg_gtok_token NAND2X1TS
XU4678 n4524 FE_OFN726_n4643 fifo_from_fft_fifo_cell9_reg_gtok_token NAND2X1TS
XU4679 n4518 FE_OFN726_n4643 fifo_from_fft_fifo_cell10_reg_gtok_token NAND2X1TS
XU4680 n4512 FE_OFN728_n4643 fifo_from_fft_fifo_cell11_reg_gtok_token NAND2X1TS
XU4681 n4131 fifo_to_fir_fifo_cell1_controller_f_i_get
+ fifo_to_fir_fifo_cell1_controller_f_i_put n9492 OA21XLTS
XU4682 n4123 fifo_to_fir_fifo_cell1_reg_gtok_token n4134 NAND2X1TS
XU4683 n4126 fifo_to_fir_fifo_cell2_controller_f_i_get
+ fifo_to_fir_fifo_cell2_controller_f_i_put n9492 OA21XLTS
XU4684 n4118 fifo_to_fir_fifo_cell2_reg_gtok_token FE_OFN686_n4134 NAND2X1TS
XU4685 n4121 fifo_to_fir_fifo_cell3_controller_f_i_get
+ fifo_to_fir_fifo_cell3_controller_f_i_put n9493 OA21XLTS
XU4686 n4116 fifo_to_fir_fifo_cell4_controller_f_i_get
+ fifo_to_fir_fifo_cell4_controller_f_i_put n9493 OA21XLTS
XU4687 n4108 fifo_to_fir_fifo_cell4_reg_gtok_token FE_OFN687_n4134 NAND2X1TS
XU4688 n4111 fifo_to_fir_fifo_cell5_controller_f_i_get
+ fifo_to_fir_fifo_cell5_controller_f_i_put n9493 OA21XLTS
XU4689 n4103 fifo_to_fir_fifo_cell5_reg_gtok_token FE_OFN687_n4134 NAND2X1TS
XU4690 n4106 fifo_to_fir_fifo_cell6_controller_f_i_get
+ fifo_to_fir_fifo_cell6_controller_f_i_put n9493 OA21XLTS
XU4691 n4098 fifo_to_fir_fifo_cell6_reg_gtok_token FE_OFN688_n4134 NAND2X1TS
XU4692 n4101 fifo_to_fir_fifo_cell7_controller_f_i_get
+ fifo_to_fir_fifo_cell7_controller_f_i_put n9494 OA21XLTS
XU4693 n4093 fifo_to_fir_fifo_cell7_reg_gtok_token FE_OFN688_n4134 NAND2X1TS
XU4694 n4096 fifo_to_fir_fifo_cell8_controller_f_i_get
+ fifo_to_fir_fifo_cell8_controller_f_i_put n9494 OA21XLTS
XU4695 n4088 fifo_to_fir_fifo_cell8_reg_gtok_token FE_OFN689_n4134 NAND2X1TS
XU4696 n4091 fifo_to_fir_fifo_cell9_controller_f_i_get
+ fifo_to_fir_fifo_cell9_controller_f_i_put n9494 OA21XLTS
XU4697 n4083 fifo_to_fir_fifo_cell9_reg_gtok_token FE_OFN692_n4134 NAND2X1TS
XU4698 n4086 fifo_to_fir_fifo_cell10_controller_f_i_get
+ fifo_to_fir_fifo_cell10_controller_f_i_put n9494 OA21XLTS
XU4699 n4078 fifo_to_fir_fifo_cell10_reg_gtok_token FE_OFN694_n4134 NAND2X1TS
XU4700 n4081 fifo_to_fir_fifo_cell11_controller_f_i_get
+ fifo_to_fir_fifo_cell11_controller_f_i_put n9495 OA21XLTS
XU4701 n4073 fifo_to_fir_fifo_cell11_reg_gtok_token FE_OFN694_n4134 NAND2X1TS
XU4702 n4076 fifo_to_fir_fifo_cell12_controller_f_i_get
+ fifo_to_fir_fifo_cell12_controller_f_i_put n9495 OA21XLTS
XU4703 n4068 fifo_to_fir_fifo_cell12_reg_gtok_token FE_OFN695_n4134 NAND2X1TS
XU4704 n4071 fifo_to_fir_fifo_cell13_controller_f_i_get
+ fifo_to_fir_fifo_cell13_controller_f_i_put n9495 OA21XLTS
XU4705 n4063 fifo_to_fir_fifo_cell13_reg_gtok_token FE_OFN695_n4134 NAND2X1TS
XU4706 n4066 fifo_to_fir_fifo_cell14_controller_f_i_get
+ fifo_to_fir_fifo_cell14_controller_f_i_put n9495 OA21XLTS
XU4707 n4061 fifo_to_fir_fifo_cell15_controller_f_i_get
+ fifo_to_fir_fifo_cell15_controller_f_i_put n9496 OA21XLTS
XU4708 n3809 fifo_to_fir_fifo_cell0_controller_f_i_get
+ fifo_to_fir_fifo_cell0_controller_f_i_put n9492 OA21XLTS
XU4710 n3956 fifo_to_fft_fifo_cell1_controller_f_i_get
+ fifo_to_fft_fifo_cell1_controller_f_i_put n9488 OA21XLTS
XU4711 n3948 fifo_to_fft_fifo_cell1_reg_gtok_token FE_OFN701_n3959 NAND2X1TS
XU4712 n3951 fifo_to_fft_fifo_cell2_controller_f_i_get
+ fifo_to_fft_fifo_cell2_controller_f_i_put n9488 OA21XLTS
XU4713 n3943 fifo_to_fft_fifo_cell2_reg_gtok_token FE_OFN704_n3959 NAND2X1TS
XU4714 n3946 fifo_to_fft_fifo_cell3_controller_f_i_get
+ fifo_to_fft_fifo_cell3_controller_f_i_put n9489 OA21XLTS
XU4715 n3938 fifo_to_fft_fifo_cell3_reg_gtok_token FE_OFN704_n3959 NAND2X1TS
XU4716 n3941 fifo_to_fft_fifo_cell4_controller_f_i_get
+ fifo_to_fft_fifo_cell4_controller_f_i_put n9489 OA21XLTS
XU4717 n3933 fifo_to_fft_fifo_cell4_reg_gtok_token FE_OFN708_n3959 NAND2X1TS
XU4718 n3936 fifo_to_fft_fifo_cell5_controller_f_i_get
+ fifo_to_fft_fifo_cell5_controller_f_i_put n9489 OA21XLTS
XU4719 n3928 fifo_to_fft_fifo_cell5_reg_gtok_token FE_OFN705_n3959 NAND2X1TS
XU4720 n3931 fifo_to_fft_fifo_cell6_controller_f_i_get
+ fifo_to_fft_fifo_cell6_controller_f_i_put n9496 OA21XLTS
XU4721 n3923 fifo_to_fft_fifo_cell6_reg_gtok_token FE_OFN705_n3959 NAND2X1TS
XU4722 n3926 fifo_to_fft_fifo_cell7_controller_f_i_get
+ fifo_to_fft_fifo_cell7_controller_f_i_put n9490 OA21XLTS
XU4723 n3918 fifo_to_fft_fifo_cell7_reg_gtok_token FE_OFN702_n3959 NAND2X1TS
XU4724 n3921 fifo_to_fft_fifo_cell8_controller_f_i_get
+ fifo_to_fft_fifo_cell8_controller_f_i_put n9490 OA21XLTS
XU4726 n3913 fifo_to_fft_fifo_cell8_reg_gtok_token FE_OFN702_n3959 NAND2X1TS
XU4727 n3916 fifo_to_fft_fifo_cell9_controller_f_i_get
+ fifo_to_fft_fifo_cell9_controller_f_i_put n9490 OA21XLTS
XU4728 n3908 fifo_to_fft_fifo_cell9_reg_gtok_token FE_OFN706_n3959 NAND2X1TS
XU4729 n3911 fifo_to_fft_fifo_cell10_controller_f_i_get
+ fifo_to_fft_fifo_cell10_controller_f_i_put n9490 OA21XLTS
XU4730 n3903 fifo_to_fft_fifo_cell10_reg_gtok_token FE_OFN707_n3959 NAND2X1TS
XU4731 n3906 fifo_to_fft_fifo_cell11_controller_f_i_get
+ fifo_to_fft_fifo_cell11_controller_f_i_put n9491 OA21XLTS
XU4732 n3898 fifo_to_fft_fifo_cell11_reg_gtok_token FE_OFN707_n3959 NAND2X1TS
XU4733 n3901 fifo_to_fft_fifo_cell12_controller_f_i_get
+ fifo_to_fft_fifo_cell12_controller_f_i_put n9491 OA21XLTS
XU4734 n3893 fifo_to_fft_fifo_cell12_reg_gtok_token FE_OFN703_n3959 NAND2X1TS
XU4735 n3896 fifo_to_fft_fifo_cell13_controller_f_i_get
+ fifo_to_fft_fifo_cell13_controller_f_i_put n9491 OA21XLTS
XU4736 n3888 fifo_to_fft_fifo_cell13_reg_gtok_token FE_OFN699_n3959 NAND2X1TS
XU4737 n3891 fifo_to_fft_fifo_cell14_controller_f_i_get
+ fifo_to_fft_fifo_cell14_controller_f_i_put n9491 OA21XLTS
XU4738 n3886 fifo_to_fft_fifo_cell15_controller_f_i_get
+ fifo_to_fft_fifo_cell15_controller_f_i_put n9492 OA21XLTS
XU4739 n3820 fifo_to_fft_fifo_cell0_controller_f_i_get
+ fifo_to_fft_fifo_cell0_controller_f_i_put n9488 OA21XLTS
XU4748 n4678 fifo_from_fir_fifo_cell15_controller_f_i_get
+ fifo_from_fir_fifo_cell15_controller_f_i_put n9487 OA21XLTS
XU4749 n4720 fifo_from_fir_fifo_cell8_controller_f_i_get
+ fifo_from_fir_fifo_cell8_controller_f_i_put n9486 OA21XLTS
XU4750 n4726 fifo_from_fir_fifo_cell7_controller_f_i_get
+ fifo_from_fir_fifo_cell7_controller_f_i_put n9485 OA21XLTS
XU4751 n4732 fifo_from_fir_fifo_cell6_controller_f_i_get
+ fifo_from_fir_fifo_cell6_controller_f_i_put n9485 OA21XLTS
XU4752 n4738 fifo_from_fir_fifo_cell5_controller_f_i_get
+ fifo_from_fir_fifo_cell5_controller_f_i_put n9485 OA21XLTS
XU4753 n4744 fifo_from_fir_fifo_cell4_controller_f_i_get
+ fifo_from_fir_fifo_cell4_controller_f_i_put n9485 OA21XLTS
XU4754 n4758 n4829 fifo_from_fir_fifo_cell1_reg_gtok_token NAND2X1TS
XU4755 n4752 FE_OFN737_n4829 fifo_from_fir_fifo_cell2_reg_gtok_token NAND2X1TS
XU4756 n4746 FE_OFN738_n4829 fifo_from_fir_fifo_cell3_reg_gtok_token NAND2X1TS
XU4757 n4740 FE_OFN740_n4829 fifo_from_fir_fifo_cell4_reg_gtok_token NAND2X1TS
XU4758 n4734 FE_OFN743_n4829 fifo_from_fir_fifo_cell5_reg_gtok_token NAND2X1TS
XU4759 n4728 FE_OFN743_n4829 fifo_from_fir_fifo_cell6_reg_gtok_token NAND2X1TS
XU4760 n4722 FE_OFN744_n4829 fifo_from_fir_fifo_cell7_reg_gtok_token NAND2X1TS
XU4761 n4716 FE_OFN744_n4829 fifo_from_fir_fifo_cell8_reg_gtok_token NAND2X1TS
XU4762 n4710 FE_OFN739_n4829 fifo_from_fir_fifo_cell9_reg_gtok_token NAND2X1TS
XU4763 n4704 FE_OFN739_n4829 fifo_from_fir_fifo_cell10_reg_gtok_token NAND2X1TS
XU4764 n4698 FE_OFN741_n4829 fifo_from_fir_fifo_cell11_reg_gtok_token NAND2X1TS
XU4810 n8838 FE_OFN697_n8052 INVX2TS
XU4811 n8871 FE_OFN679_n8050 INVX2TS
XU4816 n4561 n8837 n4637 n4638 NOR3X1TS
XU4831 n9465 FE_OFN833_n7619 INVX2TS
XU4832 n3486 router_data_from_iir router_addr_calc_iir_write_calc_counter_N40
+ NAND2X1TS
XU4833 n9480 FE_OFN782_n7619 INVX2TS
XU4835 n9497 FE_OFN813_n7619 INVX2TS
XU4836 n9406 FE_OFN988_n9431 INVX2TS
XU4837 n9432 FE_OFN976_n9462 INVX2TS
XU4838 n9407 FE_OFN986_n9431 INVX2TS
XU4839 n9514 FE_OFN789_n7619 INVX2TS
XU4840 n9435 n9462 INVX2TS
XU4841 n8376 n8055 INVX2TS
XU4842 n8711 n8054 INVX2TS
XU4847 n8472 n8056 INVX2TS
XU4849 n8137 FE_OFN664_n8053 INVX2TS
XU4876 n5702 mips_mips_accbypass FE_OFN715_n4207 AND2X2TS
XU4877 n5584 FE_OFN713_n4207 mips_mips_accfullinstruction[21] AND2X2TS
XU4878 n5585 FE_OFN713_n4207 mips_mips_accfullinstruction[20] AND2X2TS
XU4879 n5586 FE_OFN716_n4207 mips_mips_accfullinstruction[19] AND2X2TS
XU4880 n5587 FE_OFN716_n4207 mips_mips_accfullinstruction[18] AND2X2TS
XU4881 n5588 FE_OFN716_n4207 mips_mips_accfullinstruction[17] AND2X2TS
XU4882 n5589 FE_OFN713_n4207 mips_mips_accfullinstruction[16] AND2X2TS
XU4883 n5590 FE_OFN714_n4207 mips_mips_accfullinstruction[15] AND2X2TS
XU4884 n5591 FE_OFN716_n4207 mips_mips_accfullinstruction[14] AND2X2TS
XU4885 n5592 FE_OFN712_n4207 mips_mips_accfullinstruction[13] AND2X2TS
XU4886 n5593 FE_OFN715_n4207 mips_mips_accfullinstruction[12] AND2X2TS
XU4887 n5594 FE_OFN714_n4207 mips_mips_accfullinstruction[11] AND2X2TS
XU4888 n5595 FE_OFN715_n4207 mips_mips_accfullinstruction[10] AND2X2TS
XU4889 n5596 FE_OFN712_n4207 mips_mips_accfullinstruction[9] AND2X2TS
XU4890 n5597 FE_OFN709_n4207 mips_mips_accfullinstruction[8] AND2X2TS
XU4891 n5598 FE_OFN710_n4207 mips_mips_accfullinstruction[7] AND2X2TS
XU4892 n5599 FE_OFN711_n4207 mips_mips_accfullinstruction[6] AND2X2TS
XU4893 n5601 n4207 mips_mips_accfullinstruction[4] AND2X2TS
XU4894 n5604 n4207 mips_mips_accfullinstruction[1] AND2X2TS
XU4895 n5605 FE_OFN715_n4207 mips_mips_accfullinstruction[0] AND2X2TS
XU5208 n3751 FE_OFN768_n3720 router_data_cntl_data_in[2] FE_OFN757_n3721
+ FE_MDBN5_ FE_OFN747_n3722 fir_data_in[2] AOI222XLTS
XU5209 n3750 FE_OFN771_n3720 router_data_cntl_data_in[3] FE_OFN760_n3721
+ FE_MDBN6_ FE_OFN750_n3722 fir_data_in[3] AOI222XLTS
XU5210 n3748 FE_OFN770_n3720 router_data_cntl_data_in[5] FE_OFN759_n3721
+ FE_MDBN7_ FE_OFN749_n3722 fir_data_in[5] AOI222XLTS
XU5211 n3747 FE_OFN768_n3720 router_data_cntl_data_in[6] FE_OFN757_n3721
+ fft_data_in[6] FE_OFN747_n3722 fir_data_in[6] AOI222XLTS
XU5212 n3745 FE_OFN775_n3720 router_data_cntl_data_in[8] FE_OFN764_n3721
+ fft_data_in[8] FE_OFN754_n3722 fir_data_in[8] AOI222XLTS
XU5213 n3744 FE_OFN775_n3720 router_data_cntl_data_in[9] FE_OFN764_n3721
+ fft_data_in[9] FE_OFN754_n3722 fir_data_in[9] AOI222XLTS
XU5214 n3741 FE_OFN771_n3720 router_data_cntl_data_in[12] FE_OFN760_n3721
+ fft_data_in[12] FE_OFN750_n3722 fir_data_in[12] AOI222XLTS
XU5215 n3740 FE_OFN774_n3720 router_data_cntl_data_in[13] FE_OFN763_n3721
+ fft_data_in[13] FE_OFN753_n3722 fir_data_in[13] AOI222XLTS
XU5216 n3739 FE_OFN772_n3720 router_data_cntl_data_in[14] FE_OFN761_n3721
+ fft_data_in[14] FE_OFN751_n3722 fir_data_in[14] AOI222XLTS
XU5217 n3738 FE_OFN774_n3720 router_data_cntl_data_in[15] FE_OFN763_n3721
+ fft_data_in[15] FE_OFN753_n3722 fir_data_in[15] AOI222XLTS
XU5218 n3737 FE_OFN767_n3720 router_data_cntl_data_in[16] FE_OFN755_n3721
+ fft_data_in[16] FE_OFN746_n3722 fir_data_in[16] AOI222XLTS
XU5219 n3736 FE_OFN767_n3720 router_data_cntl_data_in[17] FE_OFN755_n3721
+ fft_data_in[17] FE_OFN746_n3722 fir_data_in[17] AOI222XLTS
XU5220 n3735 FE_OFN774_n3720 router_data_cntl_data_in[18] FE_OFN763_n3721
+ fft_data_in[18] FE_OFN753_n3722 fir_data_in[18] AOI222XLTS
XU5221 n3729 FE_OFN770_n3720 router_data_cntl_data_in[24] FE_OFN759_n3721
+ FE_MDBN8_ FE_OFN749_n3722 fir_data_in[24] AOI222XLTS
XU5222 n3728 FE_OFN770_n3720 router_data_cntl_data_in[25] FE_OFN759_n3721
+ fft_data_in[25] FE_OFN749_n3722 fir_data_in[25] AOI222XLTS
XU5223 n3727 FE_OFN769_n3720 router_data_cntl_data_in[26] FE_OFN758_n3721
+ FE_MDBN9_ FE_OFN748_n3722 fir_data_in[26] AOI222XLTS
XU5228 n5250 fifo_to_fft_fifo_cell0_reg_ptok_N29 fifo_to_fft_tok_xnor_put
+ NAND2X1TS
XU5229 n5208 fifo_to_fir_fifo_cell0_reg_ptok_N29 fifo_to_fir_tok_xnor_put
+ NAND2X1TS
XU5230 n5327 fifo_from_fft_fifo_cell0_reg_ptok_N29 fifo_from_fft_tok_xnor_put
+ NAND2X1TS
XU5231 n8844 n8052 INVX2TS
XU5232 n5288 fifo_from_fir_fifo_cell0_reg_ptok_N29 fifo_from_fir_tok_xnor_put
+ NAND2X1TS
XU5233 n8877 FE_OFN681_n8050 INVX2TS
XU5234 n3957 n8812 n5250 NOR2X1TS
XU5235 fifo_to_fft_fifo_cell1_data_out_N35 n7335 INVX2TS
XU5236 n4132 n8791 n5208 NOR2X1TS
XU5237 fifo_to_fir_fifo_cell1_data_out_N35 n7444 INVX2TS
XU5241 fifo_from_fft_fifo_cell2_data_out_N35 n4572 INVX2TS
XU5242 fifo_from_fft_fifo_cell3_data_out_N35 n4566 INVX2TS
XU5243 fifo_from_fft_fifo_cell4_data_out_N35 n4560 INVX2TS
XU5244 fifo_from_fft_fifo_cell5_data_out_N35 n4554 INVX2TS
XU5245 fifo_from_fft_fifo_cell6_data_out_N35 n4548 INVX2TS
XU5246 fifo_from_fft_fifo_cell7_data_out_N35 n4542 INVX2TS
XU5247 fifo_from_fft_fifo_cell8_data_out_N35 n4536 INVX2TS
XU5248 fifo_from_fft_fifo_cell9_data_out_N35 n4530 INVX2TS
XU5249 fifo_from_fft_fifo_cell10_data_out_N35 n4524 INVX2TS
XU5250 fifo_from_fft_fifo_cell11_data_out_N35 n4518 INVX2TS
XU5251 fifo_from_fft_fifo_cell12_data_out_N35 n4512 INVX2TS
XU5252 fifo_to_fir_fifo_cell3_data_out_N35 n4118 INVX2TS
XU5253 fifo_to_fir_fifo_cell5_data_out_N35 n4108 INVX2TS
XU5254 fifo_to_fir_fifo_cell6_data_out_N35 n4103 INVX2TS
XU5255 fifo_to_fir_fifo_cell7_data_out_N35 n4098 INVX2TS
XU5256 fifo_to_fir_fifo_cell8_data_out_N35 n4093 INVX2TS
XU5257 fifo_to_fir_fifo_cell9_data_out_N35 n4088 INVX2TS
XU5258 fifo_to_fir_fifo_cell10_data_out_N35 n4083 INVX2TS
XU5259 fifo_to_fir_fifo_cell11_data_out_N35 n4078 INVX2TS
XU5260 fifo_to_fir_fifo_cell12_data_out_N35 n4073 INVX2TS
XU5261 fifo_to_fir_fifo_cell13_data_out_N35 n4068 INVX2TS
XU5263 fifo_to_fir_fifo_cell14_data_out_N35 n4063 INVX2TS
XU5264 n8095 n3826 n3474 n3825 AO21X1TS
XU5265 fifo_to_fft_fifo_cell3_data_out_N35 n3943 INVX2TS
XU5266 fifo_to_fft_fifo_cell4_data_out_N35 n3938 INVX2TS
XU5267 fifo_to_fft_fifo_cell5_data_out_N35 n3933 INVX2TS
XU5268 fifo_to_fft_fifo_cell6_data_out_N35 n3928 INVX2TS
XU5269 fifo_to_fft_fifo_cell7_data_out_N35 n3923 INVX2TS
XU5270 fifo_to_fft_fifo_cell8_data_out_N35 n3918 INVX2TS
XU5271 fifo_to_fft_fifo_cell9_data_out_N35 n3913 INVX2TS
XU5272 fifo_to_fft_fifo_cell10_data_out_N35 n3908 INVX2TS
XU5273 fifo_to_fft_fifo_cell11_data_out_N35 n3903 INVX2TS
XU5274 fifo_to_fft_fifo_cell12_data_out_N35 n3898 INVX2TS
XU5275 fifo_to_fft_fifo_cell13_data_out_N35 n3893 INVX2TS
XU5277 fifo_to_fft_fifo_cell14_data_out_N35 n3888 INVX2TS
XU5282 fifo_from_fir_fifo_cell2_data_out_N35 n4758 INVX2TS
XU5283 fifo_from_fir_fifo_cell3_data_out_N35 n4752 INVX2TS
XU5284 fifo_from_fir_fifo_cell4_data_out_N35 n4746 INVX2TS
XU5285 fifo_from_fir_fifo_cell5_data_out_N35 n4740 INVX2TS
XU5286 fifo_from_fir_fifo_cell6_data_out_N35 n4734 INVX2TS
XU5287 fifo_from_fir_fifo_cell7_data_out_N35 n4728 INVX2TS
XU5288 fifo_from_fir_fifo_cell8_data_out_N35 n4722 INVX2TS
XU5289 fifo_from_fir_fifo_cell9_data_out_N35 n4716 INVX2TS
XU5290 fifo_from_fir_fifo_cell10_data_out_N35 n4710 INVX2TS
XU5291 fifo_from_fir_fifo_cell11_data_out_N35 n4704 INVX2TS
XU5292 fifo_from_fir_fifo_cell12_data_out_N35 n4698 INVX2TS
XU5294 n3777 FE_OFN841_n7619 FE_OFN419_n3776 NOR2X1TS
XU5295 n3797 FE_OFN844_n7619 FE_OFN73_n3796 NOR2X1TS
XU5297 n3796 n3792 n8844 NOR2X1TS
XU5298 n3792 fifo_from_fft_hang[14] n4488 n3784 AOI21X1TS
XU5299 n4490 FE_OFN847_n7619 FE_OFN142_n4489 NOR2X1TS
XU5300 n4488 fifo_from_fft_fifo_cell15_data_out_N35 n4489 n5312
+ fifo_from_fft_hold[15] AOI31X1TS
XU5301 n4676 FE_OFN831_n7619 FE_OFN480_n4675 NOR2X1TS
XU5302 n4489 n8840 n4601 n4602 NOR3X1TS
XU5305 n4675 n8873 n4787 n4788 NOR3X1TS
XU5306 n4486 fifo_from_fft_fifo_cell14_data_out_N35 n4495 n5313
+ fifo_from_fft_hold[14] AOI31X1TS
XU5307 n4496 FE_OFN836_n7619 FE_OFN162_n4495 NOR2X1TS
XU5308 n4672 fifo_from_fir_fifo_cell14_data_out_N35 FE_OFN496_n4681 n5274
+ fifo_from_fir_hold[14] AOI31X1TS
XU5309 n4682 FE_OFN841_n7619 FE_OFN502_n4681 NOR2X1TS
XU5311 n4495 n8840 n4604 n4605 NOR3X1TS
XU5313 n4681 n8873 n4790 n4791 NOR3X1TS
XU5314 n4484 fifo_from_fft_fifo_cell13_data_out_N35 n8711 n5314
+ fifo_from_fft_hold[13] AOI31X1TS
XU5315 n4670 fifo_from_fir_fifo_cell13_data_out_N35 n8376 n5275
+ fifo_from_fir_hold[13] AOI31X1TS
XU5318 n4482 FE_OFN175_n4507 fifo_from_fft_fifo_cell12_data_out_N35 n5315
+ fifo_from_fft_hold[12] AOI31X1TS
XU5319 n4668 n4693 fifo_from_fir_fifo_cell12_data_out_N35 n5276
+ fifo_from_fir_hold[12] AOI31X1TS
XU5320 n4480 FE_OFN199_n4513 fifo_from_fft_fifo_cell11_data_out_N35 n5316
+ fifo_from_fft_hold[11] AOI31X1TS
XU5321 n4514 FE_OFN836_n7619 FE_OFN199_n4513 NOR2X1TS
XU5322 n4666 FE_OFN534_n4699 fifo_from_fir_fifo_cell11_data_out_N35 n5277
+ fifo_from_fir_hold[11] AOI31X1TS
XU5323 n4700 FE_OFN831_n7619 n4699 NOR2X1TS
XU5326 n4478 FE_OFN209_n4519 fifo_from_fft_fifo_cell10_data_out_N35 n5317
+ fifo_from_fft_hold[10] AOI31X1TS
XU5327 n4706 FE_OFN846_n7619 FE_OFN547_n4705 NOR2X1TS
XU5328 n4664 FE_OFN546_n4705 fifo_from_fir_fifo_cell10_data_out_N35 n5278
+ fifo_from_fir_hold[10] AOI31X1TS
XU5330 n4526 FE_OFN840_n7619 FE_OFN223_n4525 NOR2X1TS
XU5331 n4476 n4525 fifo_from_fft_fifo_cell9_data_out_N35 n5318
+ fifo_from_fft_hold[9] AOI31X1TS
XU5332 n4712 FE_OFN837_n7619 FE_OFN560_n4711 NOR2X1TS
XU5333 n4662 n4711 fifo_from_fir_fifo_cell9_data_out_N35 n5279
+ fifo_from_fir_hold[9] AOI31X1TS
XU5338 n4532 FE_OFN840_n7619 FE_OFN233_n4531 NOR2X1TS
XU5339 n4531 n8838 n4622 n4623 NOR3X1TS
XU5340 n4717 n8871 n4808 n4809 NOR3X1TS
XU5341 n4538 FE_OFN847_n7619 FE_OFN247_n4537 NOR2X1TS
XU5342 n4472 FE_OFN247_n4537 fifo_from_fft_fifo_cell7_data_out_N35 n5320
+ fifo_from_fft_hold[7] AOI31X1TS
XU5343 n4658 FE_OFN593_n4723 fifo_from_fir_fifo_cell7_data_out_N35 n5281
+ fifo_from_fir_hold[7] AOI31X1TS
XU5344 n4724 FE_OFN837_n7619 FE_OFN595_n4723 NOR2X1TS
XU5346 n4537 n8838 n4625 n4626 NOR3X1TS
XU5348 n4723 n8871 n4811 n4812 NOR3X1TS
XU5349 n4470 n4543 fifo_from_fft_fifo_cell6_data_out_N35 n5321
+ fifo_from_fft_hold[6] AOI31X1TS
XU5350 n4544 FE_OFN835_n7619 FE_OFN267_n4543 NOR2X1TS
XU5351 n4656 n4729 fifo_from_fir_fifo_cell6_data_out_N35 n5282
+ fifo_from_fir_hold[6] AOI31X1TS
XU5352 n4543 n8838 n4628 n4629 NOR3X1TS
XU5353 n4729 n8871 n4814 n4815 NOR3X1TS
XU5354 n4550 FE_OFN844_n7619 FE_OFN290_n4549 NOR2X1TS
XU5355 n4468 n4549 fifo_from_fft_fifo_cell5_data_out_N35 n5322
+ fifo_from_fft_hold[5] AOI31X1TS
XU5356 n4736 FE_OFN845_n7619 FE_OFN621_n4735 NOR2XLTS
XU5357 n4654 FE_OFN618_n4735 fifo_from_fir_fifo_cell5_data_out_N35 n5283
+ fifo_from_fir_hold[5] AOI31X1TS
XU5358 n4549 n8837 n4631 n4632 NOR3X1TS
XU5359 n4466 n4555 fifo_from_fft_fifo_cell4_data_out_N35 n5323
+ fifo_from_fft_hold[4] AOI31X1TS
XU5360 n4556 FE_OFN835_n7619 FE_OFN302_n4555 NOR2X1TS
XU5361 n4652 FE_OFN642_n4741 fifo_from_fir_fifo_cell4_data_out_N35 n5284
+ fifo_from_fir_hold[4] AOI31X1TS
XU5362 n4742 FE_OFN845_n7619 FE_OFN646_n4741 NOR2X1TS
XU5363 n4555 n8837 n4634 n4635 NOR3X1TS
XU5364 n4464 FE_OFN313_n4561 fifo_from_fft_fifo_cell3_data_out_N35 n5324
+ fifo_from_fft_hold[3] AOI31X1TS
XU5365 n4650 FE_OFN653_n4747 fifo_from_fir_fifo_cell3_data_out_N35 n5285
+ fifo_from_fir_hold[3] AOI31X1TS
XU5370 n4648 n8137 fifo_from_fir_fifo_cell2_data_out_N35 n5286
+ fifo_from_fir_hold[2] AOI31X1TS
XU5371 n3722 FE_OFN765_n3720 n3754 NOR2X1TS
XU5373 n3531 n3563 n3564 FE_OFN903_n3530 AOI21X1TS
XU5375 n3575 n3607 n3608 FE_OFN921_n3574 AOI21X1TS
XU5376 n3721 n3720 n3755 NOR2X1TS
XU5377 n3663 n3695 n3696 FE_OFN881_n3662 AOI21X1TS
XU5378 n3619 n3651 n3652 FE_OFN970_n3618 AOI21X1TS
XU5381 n8056 n8837 n4640 n4641 OR3X1TS
XU5383 n4646 FE_OFN666_n4759 fifo_from_fir_fifo_cell1_data_out_N35 n5287
+ fifo_from_fir_hold[1] AOI31X1TS
XU5384 n4460 n4573 fifo_from_fft_fifo_cell1_data_out_N35 n5326
+ fifo_from_fft_hold[1] AOI31X1TS
XU5385 n3754 n7203 n3829 NAND2X1TS
XU5387 n3487 n3519 n3520 FE_OFN944_n3486 AOI21X1TS
XU5388 n8058 n3714 router_fft_put_req_reg n9465 n3484 AND4X1TS
XU5392 n4702 fifo_from_fir_fifo_cell11_controller_f_i_get
+ fifo_from_fir_fifo_cell11_controller_f_i_put n9486 OA21XLTS
XU5393 n4756 fifo_from_fir_fifo_cell2_controller_f_i_get
+ fifo_from_fir_fifo_cell2_controller_f_i_put n9484 OA21XLTS
XU5394 n4696 fifo_from_fir_fifo_cell12_controller_f_i_get
+ fifo_from_fir_fifo_cell12_controller_f_i_put n9487 OA21XLTS
XU5395 n4762 fifo_from_fir_fifo_cell1_controller_f_i_get
+ fifo_from_fir_fifo_cell1_controller_f_i_put n9484 OA21XLTS
XU5396 n4750 fifo_from_fir_fifo_cell3_controller_f_i_get
+ fifo_from_fir_fifo_cell3_controller_f_i_put n9484 OA21XLTS
XU5397 n4690 fifo_from_fir_fifo_cell13_controller_f_i_get
+ fifo_from_fir_fifo_cell13_controller_f_i_put n9487 OA21XLTS
XU5398 n4684 fifo_from_fir_fifo_cell14_controller_f_i_get
+ fifo_from_fir_fifo_cell14_controller_f_i_put n9487 OA21XLTS
XU5399 n4516 fifo_from_fft_fifo_cell11_controller_f_i_get
+ fifo_from_fft_fifo_cell11_controller_f_i_put n9482 OA21XLTS
XU5400 n4558 fifo_from_fft_fifo_cell4_controller_f_i_get
+ fifo_from_fft_fifo_cell4_controller_f_i_put n9480 OA21XLTS
XU5401 n4528 fifo_from_fft_fifo_cell9_controller_f_i_get
+ fifo_from_fft_fifo_cell9_controller_f_i_put n9482 OA21XLTS
XU5402 n4708 fifo_from_fir_fifo_cell10_controller_f_i_get
+ fifo_from_fir_fifo_cell10_controller_f_i_put n9486 OA21XLTS
XU5403 n4522 fifo_from_fft_fifo_cell10_controller_f_i_get
+ fifo_from_fft_fifo_cell10_controller_f_i_put n9482 OA21XLTS
XU5404 n4714 fifo_from_fir_fifo_cell9_controller_f_i_get
+ fifo_from_fir_fifo_cell9_controller_f_i_put n9486 OA21XLTS
XU5405 n9485 FE_OFN829_n7619 INVX2TS
XU5406 n4576 fifo_from_fft_fifo_cell1_controller_f_i_get
+ fifo_from_fft_fifo_cell1_controller_f_i_put n9497 OA21XLTS
XU5407 n3715 n9406 n7953 n9432 n3713 AOI211X1TS
XU5408 n3713 n9407 n3850 n7211 NAND3X1TS
XU5410 n3563 n3569 n3570 n3571 n3572 NOR4XLTS
XU5411 n3519 n3525 n3526 n3527 n3528 NOR4XLTS
XU5412 n3607 n3613 n3614 n3615 n3616 NOR4XLTS
XU5413 n3695 n3701 n3702 n3703 n3704 NOR4XLTS
XU5414 n3651 n3657 n3658 n3659 n3660 NOR4XLTS
XU5415 n3608 n3609 n3610 n3611 n3612 NOR4XLTS
XU5416 n3564 n3565 n3566 n3567 n3568 NOR4XLTS
XU5417 n3652 n3653 n3654 n3655 n3656 NOR4XLTS
XU5418 n3696 n3697 n3698 n3699 n3700 NOR4XLTS
XU5419 n3520 n3521 n3522 n3523 n3524 NOR4XLTS
XU5420 n6768 fifo_to_fft_fifo_cell7_controller_valid_read n7301
+ fifo_to_fft_fifo_cell7_controller_write_enable NOR3X1TS
XU5421 n3865 n3927 fifo_to_fft_fifo_cell7_data_out_N35 n6768
+ fifo_to_fft_hold[7] AOI31X1TS
XU5422 n6769 fifo_to_fft_fifo_cell10_controller_valid_read n7276
+ fifo_to_fft_fifo_cell10_controller_write_enable NOR3X1TS
XU5423 n3871 n3912 fifo_to_fft_fifo_cell10_data_out_N35 n6769
+ fifo_to_fft_hold[10] AOI31X1TS
XU5424 n6770 n4067 CLKINVX1TS
XU5425 n6771 n6770 n7365 n7366 n6770 AOI2BB2X1TS
XU5426 n6772 n7405 n7395 n7404 n7394 AOI2BB2X1TS
XU5427 n6773 n6772 n4198 XOR2X1TS
XU5428 n6774 n4122 n4127 XOR2X1TS
XU5429 n6775 n6773 n6774 XOR2X1TS
XU5430 n6776 n4087 n6775 XOR2X1TS
XU5431 n6777 n4107 CLKINVX1TS
XU5432 n6778 n6777 n7424 n7425 n6777 AOI2BB2X1TS
XU5433 n6779 n4117 n6778 XOR2X1TS
XU5434 n6780 n6776 n6779 XOR2X1TS
XU5435 n6781 n6771 n6780 XOR2X1TS
XU5436 n6782 n4082 CLKINVX1TS
XU5437 n6783 n6782 n7374 n7375 n6782 AOI2BB2X1TS
XU5438 n6784 n6783 n4102 XOR2X1TS
XU5439 n6785 n6781 n6784 XOR2X1TS
XU5440 n3804 n6785 n4062 XOR2X1TS
XU5441 n6786 n3881 n7236 n7242 fifo_to_fft_fifo_cell15_controller_write_enable
+ NOR4XLTS
XU5442 n6787 fifo_to_fft_fifo_cell15_controller_valid_read CLKINVX1TS
XU5443 n3880 n6786 n6787 fifo_to_fft_hold[15] AO21X1TS
XU5444 n3733 FE_OFN773_n3720 router_data_cntl_data_in[20] FE_OFN762_n3721
+ fft_data_in[20] FE_OFN752_n3722 fir_data_in[20] AOI222XLTS
XU5445 n3726 FE_OFN768_n3720 router_data_cntl_data_in[27] FE_OFN757_n3721
+ FE_MDBN10_ FE_OFN747_n3722 fir_data_in[27] AOI222XLTS
XU5446 n6788 fifo_from_fft_fifo_cell2_controller_valid_read n7519
+ fifo_from_fft_fifo_cell2_controller_write_enable NOR3X1TS
XU5447 n4462 n8472 fifo_from_fft_fifo_cell2_data_out_N35 n6788
+ fifo_from_fft_hold[2] AOI31X1TS
XU5448 n6789 fifo_to_fir_fifo_cell2_controller_valid_read n7440
+ fifo_to_fir_fifo_cell2_controller_write_enable NOR3X1TS
XU5449 n4030 n4127 fifo_to_fir_fifo_cell2_data_out_N35 n6789
+ fifo_to_fir_hold[2] AOI31X1TS
XU5450 n6790 fifo_to_fir_fifo_cell6_controller_valid_read n7415
+ fifo_to_fir_fifo_cell6_controller_write_enable NOR3X1TS
XU5451 n4038 n4107 fifo_to_fir_fifo_cell6_data_out_N35 n6790
+ fifo_to_fir_hold[6] AOI31X1TS
XU5452 n6791 fifo_to_fir_fifo_cell11_controller_valid_read n7380
+ fifo_to_fir_fifo_cell11_controller_write_enable NOR3X1TS
XU5453 n4048 n4082 fifo_to_fir_fifo_cell11_data_out_N35 n6791
+ fifo_to_fir_hold[11] AOI31X1TS
XU5454 n6792 n5288 n9515 NAND2X1TS
XU5455 n3767 fifo_from_fir_fifo_cell0_reg_ptok_out_valid_get
+ fifo_from_fir_fifo_cell0_reg_ptok_out_valid_put n6792
+ fifo_from_fir_fifo_cell0_reg_ptok_N29 OAI31X1TS
XU5456 n6793 n3907 CLKINVX1TS
XU5457 n6794 n6793 n7265 n7266 n6793 AOI2BB2X1TS
XU5458 n6795 n3932 CLKINVX1TS
XU5459 n6796 n6795 n7315 n7316 n6795 AOI2BB2X1TS
XU5460 n6797 FE_OFN678_n7295 n7286 FE_OFN678_n7295 n7285 AOI2BB2X1TS
XU5461 n6798 n6797 n4023 XOR2X1TS
XU5462 n6799 n3947 n3952 XOR2X1TS
XU5463 n6800 n6798 n6799 XOR2X1TS
XU5464 n6801 n3912 n6800 XOR2X1TS
XU5465 n6802 n3942 n6796 XOR2X1TS
XU5466 n6803 n6801 n6802 XOR2X1TS
XU5467 n6804 n3892 CLKINVX1TS
XU5468 n6805 n6804 n7255 n7256 n6804 AOI2BB2X1TS
XU5469 n6806 n6805 n6803 XOR2X1TS
XU5470 n6807 n6794 n3927 XOR2X1TS
XU5471 n6808 n6806 n6807 XOR2X1TS
XU5472 n3815 n6808 n3887 XOR2X1TS
XU5473 n6809 n4056 n7345 n7351 fifo_to_fir_fifo_cell15_controller_write_enable
+ NOR4XLTS
XU5474 n6810 fifo_to_fir_fifo_cell15_controller_valid_read CLKINVX1TS
XU5475 n4055 n6809 n6810 fifo_to_fir_hold[15] AO21X1TS
XU5476 n6811 n7260 n7251 n7246 n7241 NOR4X1TS
XU5477 n6812 n7290 n7280 n7275 n7270 NOR4X1TS
XU5478 n6813 n7320 n7310 n7305 n7300 NOR4X1TS
XU5479 n6814 n7231 n7340 n7330 n7325 NOR4X1TS
XU5480 n3484 n6811 n6812 n6813 n6814 NAND4X2TS
XU5481 n6815 n7543 n7538 n7533 n7528 NOR4X1TS
XU5482 n6816 n7563 n7558 n7553 n7548 NOR4X1TS
XU5483 n6817 n7583 n7578 n7573 n7568 NOR4X1TS
XU5484 n6818 n7216 n7598 n7593 n7588 NOR4XLTS
XU5485 n3465 n6815 n6816 n6817 n6818 NAND4X2TS
XU5486 n6819 n3783 n3784 NOR2X1TS
XU5487 n6820 n3787 n6819 FE_OFN698_n8052 FE_OFN783_n7619 OAI2BB2XLTS
XU5488 n5418 FE_OFN698_n8052 n3780 n9464 n6820 OAI211X1TS
XU5489 n3734 FE_OFN771_n3720 router_data_cntl_data_in[19] FE_OFN760_n3721
+ fft_data_in[19] FE_OFN750_n3722 fir_data_in[19] AOI222XLTS
XU5490 n3725 FE_OFN767_n3720 router_data_cntl_data_in[28] FE_OFN755_n3721
+ FE_MDBN11_ FE_OFN746_n3722 FE_MDBN0_ AOI222XLTS
XU5491 add_x_22_1_carry[31] add_x_22_1_carry[30] n7367 NOR2BX1TS
XU5492 router_addr_calc_fft_write_calc_counter_N76 n7367 add_x_22_1_carry[30]
+ XNOR2X1TS
XU5493 add_x_22_0_carry[30] add_x_22_0_carry[29] n7491 NOR2BX1TS
XU5494 router_addr_calc_fft_read_calc_counter_N75 n7491 add_x_22_0_carry[29]
+ XNOR2X1TS
XU5495 add_x_22_3_carry[30] add_x_22_3_carry[29] n7123 NOR2BX1TS
XU5496 router_addr_calc_fir_write_calc_counter_N75 n7123 add_x_22_3_carry[29]
+ XNOR2X1TS
XU5497 n6821 n7304 FE_OFN1271_router_addr_calc_fir_read_calc_count_15_ n7309
+ NAND3X1TS
XU5498 n6822 router_addr_calc_fir_read_calc_count[0] n7364 n7354 n7359
+ NAND4X1TS
XU5499 n6823 FE_OFN1276_router_addr_calc_fir_read_calc_count_5_ n7339 n7344
+ n7349 AND4X1TS
XU5500 n6824 router_addr_calc_fir_read_calc_count[9] n7334 n7329 n6823
+ NAND4X1TS
XU5501 n6825 n7324 n7319 n7314 NAND3X1TS
XU5502 n6826 n7294 n7299 FE_OFN1260_router_addr_calc_fir_read_calc_count_19_
+ NAND3X1TS
XU5503 n6827 n6822 n6824 n6825 n6826 NOR4XLTS
XU5504 n6828 FE_OFN1253_n7283 FE_OFN1250_n7278 n7289 n6827 NAND4X1TS
XU5505 n6829 FE_OFN1247_router_addr_calc_fir_read_calc_count_23_
+ FE_OFN1243_n7273 FE_OFN1242_n7268 NAND3X1TS
XU5506 n6830 router_addr_calc_fir_read_calc_count[27] n7263 n7258 NAND3X1TS
XU5507 n6831 n6821 n6828 n6829 n6830 NOR4XLTS
XU5508 router_addr_calc_fir_read_calc_counter_N40 n6831 FE_OFN1235_n7254 n7249
+ FE_OFN1230_router_addr_calc_fir_read_calc_count_30_ NAND4X1TS
XU5509 n6832 fifo_to_fft_fifo_cell3_controller_valid_read n7326
+ fifo_to_fft_fifo_cell3_controller_write_enable NOR3X1TS
XU5510 n3857 n3947 fifo_to_fft_fifo_cell3_data_out_N35 n6832
+ fifo_to_fft_hold[3] AOI31X1TS
XU5511 n6833 fifo_to_fft_fifo_cell6_controller_valid_read n7306
+ fifo_to_fft_fifo_cell6_controller_write_enable NOR3X1TS
XU5512 n3863 n3932 fifo_to_fft_fifo_cell6_data_out_N35 n6833
+ fifo_to_fft_hold[6] AOI31X1TS
XU5513 n6834 fifo_to_fft_fifo_cell9_controller_valid_read n7281
+ fifo_to_fft_fifo_cell9_controller_write_enable NOR3X1TS
XU5514 n3869 n7285 fifo_to_fft_fifo_cell9_data_out_N35 n6834
+ fifo_to_fft_hold[9] AOI31X1TS
XU5515 n6835 FE_OFN474_n4675 FE_OFN555_n4705 XOR2X1TS
XU5516 n6836 FE_OFN543_n4699 FE_OFN511_n4693 FE_OFN543_n4699 FE_OFN511_n4693
+ AOI2BB2X1TS
XU5517 n6837 FE_OFN641_n4741 n4781 XOR2XLTS
XU5518 n6838 FE_OFN652_n4747 n8053 XOR2X1TS
XU5519 n6839 n6837 n6838 XOR2X1TS
XU5520 n6840 FE_OFN568_n4711 n6839 XOR2XLTS
XU5521 n6841 FE_OFN602_n4723 FE_OFN580_n4717 FE_OFN602_n4723 FE_OFN580_n4717
+ AOI2BB2X1TS
XU5522 n6842 FE_OFN626_n4735 FE_OFN612_n4729 FE_OFN626_n4735 FE_OFN612_n4729
+ AOI2BB2X1TS
XU5523 n6843 n6841 n6842 XOR2X1TS
XU5524 n6844 n6840 n6843 XOR2X1TS
XU5525 n6845 n6836 n6844 XOR2X1TS
XU5526 n6846 n6835 n6845 XOR2X1TS
XU5527 n6847 FE_OFN508_n8055 CLKINVX1TS
XU5528 n6848 n6847 FE_OFN497_n4681 n4681 n6847 AOI2BB2X1TS
XU5529 n3764 n6846 n6848 XOR2X1TS
XU5530 n6849 fifo_to_fft_fifo_cell12_controller_valid_read n7261
+ fifo_to_fft_fifo_cell12_controller_write_enable NOR3X1TS
XU5531 n3875 n7265 fifo_to_fft_fifo_cell12_data_out_N35 n6849
+ fifo_to_fft_hold[12] AOI31X1TS
XU5532 n6850 n5327 n9515 NAND2X1TS
XU5533 n3787 fifo_from_fft_fifo_cell0_reg_ptok_out_valid_get
+ fifo_from_fft_fifo_cell0_reg_ptok_out_valid_put n6850
+ fifo_from_fft_fifo_cell0_reg_ptok_N29 OAI31X1TS
XU5534 n6851 fifo_to_fft_fifo_cell14_controller_valid_read n7247
+ fifo_to_fft_fifo_cell14_controller_write_enable NOR3X1TS
XU5535 n3879 fifo_to_fft_fifo_cell14_data_out_N35 n3892 n6851
+ fifo_to_fft_hold[14] AOI31X1TS
XU5536 n6852 n7174 n7168 FE_OFN1244_router_addr_calc_iir_write_calc_count_23_
+ n7162 NOR4X1TS
XU5537 n6853 n7952 n7113 NAND2X1TS
XU5538 n6854 FE_OFN1441_router_addr_calc_iir_write_calc_count_16_ n7133 n7127
+ n7139 NOR4XLTS
XU5539 n6855 FE_OFN1440_router_addr_calc_iir_write_calc_count_19_ n7145 n7157
+ n7151 NOR4XLTS
XU5540 n6856 FE_OFN1280_router_addr_calc_iir_write_calc_count_9_ n7093 n7090
+ n7099 NOR4XLTS
XU5541 n6857 n7110 n7105 n7122 n7116 NOR4XLTS
XU5542 n6858 n6854 n6855 n6856 n6857 NAND4X1TS
XU5543 n6859 FE_OFN1439_router_addr_calc_iir_write_calc_count_27_ n7180 n6853
+ n6858 NOR4XLTS
XU5544 n6860 FE_OFN1442_router_addr_calc_iir_write_calc_count_0_ n7198 n7186
+ n7106 OR4X1TS
XU5545 n6861 FE_OFN1281_router_addr_calc_iir_write_calc_count_5_ n7096 n7192
+ n6860 NOR4XLTS
XU5546 router_addr_calc_iir_write_calc_counter_N40 n6852 n6859 n7102 n6861
+ NAND4X1TS
XU5547 n6862 n7469 n7464 n7459 n7454 NOR4XLTS
XU5548 n6863 n7489 n7484 n7479 n7474 NOR4X1TS
XU5549 n6864 n7508 n7503 n7498 n7493 NOR4X1TS
XU5550 n6865 n7221 n7523 n7518 n7513 NOR4X1TS
XU5551 n3477 n6862 n6863 n6864 n6865 NAND4X2TS
XU5552 n4136 FE_OFN733_n8057 n4181 NOR2BX1TS
XU5553 n6866 n7369 n7360 n7355 n7350 NOR4X1TS
XU5554 n6867 n7399 n7389 n7384 n7379 NOR4XLTS
XU5555 n6868 n7429 n7419 n7414 n7409 NOR4XLTS
XU5556 n6869 n7226 n7449 n7439 n7434 NOR4XLTS
XU5557 n3474 n6866 n6867 n6868 n6869 AND4X2TS
XU5558 n6870 router_addr_calc_iir_read_calc_count[22]
+ router_addr_calc_iir_read_calc_count[23]
+ router_addr_calc_iir_read_calc_count[25]
+ router_addr_calc_iir_read_calc_count[24] NOR4XLTS
XU5559 n6871 router_addr_calc_iir_read_calc_count[31]
+ router_addr_calc_iir_read_calc_count[0]
+ router_addr_calc_iir_read_calc_count[28]
+ router_addr_calc_iir_read_calc_count[29] NOR4XLTS
XU5560 n6872 router_addr_calc_iir_read_calc_count[12]
+ router_addr_calc_iir_read_calc_count[11]
+ router_addr_calc_iir_read_calc_count[13]
+ router_addr_calc_iir_read_calc_count[10] NOR4XLTS
XU5561 n6873 router_addr_calc_iir_read_calc_count[6]
+ router_addr_calc_iir_read_calc_count[7]
+ router_addr_calc_iir_read_calc_count[9]
+ router_addr_calc_iir_read_calc_count[8] NOR4XLTS
XU5562 n6874 router_addr_calc_iir_read_calc_count[2] n6871 n6872 n6873
+ NAND4X1TS
XU5563 n6875 router_addr_calc_iir_read_calc_count[4]
+ router_addr_calc_iir_read_calc_count[5] n6874 NOR3X1TS
XU5564 n6876 router_addr_calc_iir_read_calc_count[18]
+ router_addr_calc_iir_read_calc_count[19]
+ router_addr_calc_iir_read_calc_count[21]
+ router_addr_calc_iir_read_calc_count[20] NOR4XLTS
XU5565 n6877 router_addr_calc_iir_read_calc_count[14]
+ router_addr_calc_iir_read_calc_count[15]
+ router_addr_calc_iir_read_calc_count[17]
+ router_addr_calc_iir_read_calc_count[16] NOR4XLTS
XU5566 n6878 router_addr_calc_iir_read_calc_count[3] n6875 n6876 n6877
+ NAND4X1TS
XU5567 n6879 router_addr_calc_iir_read_calc_count[26]
+ router_addr_calc_iir_read_calc_count[27] n6878 NOR3X1TS
XU5568 router_addr_calc_iir_read_calc_counter_N40
+ router_addr_calc_iir_read_calc_count[1] n8011 n6870 n6879 NAND4X1TS
XU5569 n6880 n3814 n3815 NOR2X1TS
XU5570 n6881 n3818 n6880 n8058 FE_OFN782_n7619 OAI2BB2XLTS
XU5571 n5455 n8058 n3811 n9463 n6881 OAI211X1TS
XU5572 n6882 n7578 n7583 n7568 n7573 NAND4X1TS
XU5573 n6883 n7216 n7588 n7593 n7598 NAND4X1TS
XU5574 n6884 n7533 n7538 n7528 n7543 NAND4X1TS
XU5575 n6885 n7548 n7558 n7563 n7553 NAND4X1TS
XU5576 fifo_from_fir_empty_det_N4 n6882 n6883 n6884 n6885 NOR4X1TS
XU5577 n6886 router_iir_get_req_reg router_fir_get_req_reg n4830 OAI21X1TS
XU5578 n6887 n7610 FE_OFN1282_router_fft_get_req_reg n6886 OAI2BB1X1TS
XU5579 n6888 router_fir_get_req_reg FE_OFN990_n9431
+ FE_OFN1282_router_fft_get_req_reg NOR3BX1TS
XU5580 n6889 n9390 n4832 n7611 OAI21X1TS
XU5581 n6890 n9432 FE_OFN1282_router_fft_get_req_reg n6888 n6889 AOI211X1TS
XU5582 n6891 n6890 n3754 n4644 n3832 NAND4X1TS
XU5583 n6763 router_ram_write_enable_reg n6887 n6891 CLKMX2X2TS
XU5584 n3746 FE_OFN766_n3720 router_data_cntl_data_in[7] FE_OFN756_n3721
+ FE_MDBN15_ FE_OFN745_n3722 fir_data_in[7] AOI222XLTS
XU5585 n3732 FE_OFN773_n3720 router_data_cntl_data_in[21] FE_OFN762_n3721
+ fft_data_in[21] FE_OFN752_n3722 fir_data_in[21] AOI222XLTS
XU5586 n3724 FE_OFN765_n3720 router_data_cntl_data_in[29] FE_OFN755_n3721
+ FE_MDBN12_ n3722 FE_MDBN1_ AOI222XLTS
XU5587 n6892 instruction[27] instruction[29] instruction[0] instruction[26]
+ NAND4X1TS
XU5588 n6893 instruction[17] instruction[16] instruction[15] instruction[14]
+ NOR4XLTS
XU5589 n6894 instruction[13] instruction[12] instruction[11] instruction[10]
+ NOR4XLTS
XU5590 n6895 instruction[25] instruction[24] instruction[23] instruction[22]
+ NOR4XLTS
XU5591 n6896 instruction[21] instruction[20] instruction[19] instruction[18]
+ NOR4XLTS
XU5592 n6897 n6893 n6894 n6895 n6896 NAND4X1TS
XU5593 n6898 n3458 n6892 n6897 NOR3X1TS
XU5594 n6899 instruction[28] instruction[8] instruction[9] instruction[7]
+ NOR4BX1TS
XU5595 n6900 instruction[6] instruction[5] instruction[4] instruction[3]
+ NOR4XLTS
XU5596 n4840 router_pla_top_instruction_valid n6898 n6899 n6900 NAND4X1TS
XU5597 n6901 FE_OFN1263_router_addr_calc_fft_read_calc_count_16_ n7542 n7547
+ NAND3X1TS
XU5598 n6902 FE_OFN1444_router_addr_calc_fft_read_calc_count_0_ n7602 n7592
+ n7597 NAND4X1TS
XU5599 n6903 FE_OFN1273_router_addr_calc_fft_read_calc_count_5_ n7577 n7582
+ n7587 AND4X1TS
XU5600 n6904 FE_OFN1267_router_addr_calc_fft_read_calc_count_9_ n7572 n7567
+ n6903 NAND4X1TS
XU5601 n6905 n7562 n7557 n7552 NAND3X1TS
XU5602 n6906 n7532 n7537 FE_OFN1258_router_addr_calc_fft_read_calc_count_19_
+ NAND3X1TS
XU5603 n6907 n6902 n6904 n6905 n6906 NOR4XLTS
XU5604 n6908 n7521 n7516 n7527 n6907 NAND4X1TS
XU5605 n6909 FE_OFN1245_router_addr_calc_fft_read_calc_count_23_ n7511 n7506
+ NAND3X1TS
XU5606 n6910 FE_OFN1237_router_addr_calc_fft_read_calc_count_27_ n7501 n7496
+ NAND3X1TS
XU5607 n6911 n6901 n6908 n6909 n6910 NOR4X1TS
XU5608 router_addr_calc_fft_read_calc_counter_N40 n6911 FE_OFN1234_n7492 n7487
+ FE_OFN1229_router_addr_calc_fft_read_calc_count_30_ NAND4X1TS
XU5609 n6912 n7418 FE_OFN1270_router_addr_calc_fft_write_calc_count_15_ n7423
+ NAND3X1TS
XU5610 n6913 router_addr_calc_fft_write_calc_count[0] n7483 n7473 n7478
+ NAND4X1TS
XU5611 n6914 n7463 n7453 n7458 n7468 AND4X1TS
XU5612 n6915 router_addr_calc_fft_write_calc_count[9] n7448 n7443 n6914
+ NAND4X1TS
XU5613 n6916 n7438 n7433 n7428 NAND3X1TS
XU5614 n6917 n7408 n7413 FE_OFN1259_router_addr_calc_fft_write_calc_count_19_
+ NAND3X1TS
XU5615 n6918 n6913 n6915 n6916 n6917 NOR4XLTS
XU5616 n6919 FE_OFN1252_n7397 FE_OFN1249_n7392 n7403 n6918 NAND4X1TS
XU5617 n6920 FE_OFN1246_router_addr_calc_fft_write_calc_count_23_ n7387 n7382
+ NAND3X1TS
XU5618 n6921 FE_OFN1238_router_addr_calc_fft_write_calc_count_27_ n7377 n7372
+ NAND3X1TS
XU5619 n6922 n6912 n6919 n6920 n6921 NOR4XLTS
XU5620 router_addr_calc_fft_write_calc_counter_N40 n6922
+ FE_OFN1233_router_addr_calc_fft_write_calc_count_29_
+ FE_OFN1228_router_addr_calc_fft_write_calc_count_31_ FE_OFN1232_n7368
+ NAND4X1TS
XU5621 n6923 FE_OFN1264_router_addr_calc_fir_write_calc_count_16_ n7184 n7190
+ NAND3X1TS
XU5622 n6924 FE_OFN1445_router_addr_calc_fir_write_calc_count_0_ n7245 n7235
+ n7240 NAND4X1TS
XU5623 n6925 FE_OFN1272_router_addr_calc_fir_write_calc_count_5_ n7220 n7225
+ n7230 AND4X1TS
XU5624 n6926 router_addr_calc_fir_write_calc_count[9] n7215 n7210 n6925
+ NAND4X1TS
XU5625 n6927 n7206 n7202 n7196 NAND3X1TS
XU5626 n6928 n7172 n7178 FE_OFN1261_router_addr_calc_fir_write_calc_count_19_
+ NAND3X1TS
XU5627 n6929 n6924 n6926 n6927 n6928 NOR4XLTS
XU5628 n6930 FE_OFN1254_n7159 FE_OFN1251_n7153 n7166 n6929 NAND4X1TS
XU5629 n6931 router_addr_calc_fir_write_calc_count[23] n7147 n7141 NAND3X1TS
XU5630 n6932 FE_OFN1240_router_addr_calc_fir_write_calc_count_27_ n7135 n7129
+ NAND3X1TS
XU5631 n6933 n6923 n6930 n6931 n6932 NOR4XLTS
XU5632 router_addr_calc_fir_write_calc_counter_N40 n6933 n7124 n7118
+ FE_OFN1231_router_addr_calc_fir_write_calc_count_30_ NAND4X1TS
XU5633 n6934 fifo_from_fir_fifo_cell8_controller_valid_read n7564
+ fifo_from_fir_fifo_cell8_controller_write_enable NOR3X1TS
XU5634 n4660 n4717 fifo_from_fir_fifo_cell8_data_out_N35 n6934
+ fifo_from_fir_hold[8] AOI31X1TS
XU5635 n6935 fifo_from_fir_fifo_cell15_controller_valid_read n7529
+ fifo_from_fir_fifo_cell15_controller_write_enable NOR3X1TS
XU5636 n4674 fifo_from_fir_fifo_cell15_data_out_N35 n4675 n6935
+ fifo_from_fir_hold[15] AOI31X1TS
XU5637 n3961 n8058 n4006 NOR2BX1TS
XU5638 n6936 n4513 n4507 n4513 n4507 AOI2BB2X1TS
XU5639 n6937 FE_OFN250_n4537 FE_OFN232_n4531 FE_OFN250_n4537 FE_OFN232_n4531
+ AOI2BB2X1TS
XU5640 n6938 FE_OFN289_n4549 FE_OFN274_n4543 FE_OFN289_n4549 FE_OFN274_n4543
+ AOI2BB2X1TS
XU5641 n6939 FE_OFN301_n4555 n4595 XOR2X1TS
XU5642 n6940 FE_OFN320_n4561 n8056 XOR2XLTS
XU5643 n6941 n6939 n6940 XOR2X1TS
XU5644 n6942 n4525 n6941 XOR2XLTS
XU5645 n6943 n6937 n6938 XOR2X1TS
XU5646 n6944 n6942 n6943 XOR2X1TS
XU5647 n6945 FE_OFN139_n4489 FE_OFN209_n4519 XOR2X1TS
XU5648 n6946 n6936 n6944 XOR2X1TS
XU5649 n6947 n6945 n6946 XOR2X1TS
XU5650 n6948 n8054 CLKINVX1TS
XU5651 n6949 n6948 FE_OFN161_n4495 FE_OFN161_n4495 n6948 AOI2BB2X1TS
XU5652 n3784 n6947 n6949 XOR2X1TS
XU5653 n6950 n3803 n3804 NOR2X1TS
XU5654 n6951 n3807 n6950 FE_OFN733_n8057 FE_OFN787_n7619 OAI2BB2XLTS
XU5655 n5453 FE_OFN732_n8057 n3800 n9463 n6951 OAI211X1TS
XU5656 n6952 n7503 n7508 n7493 n7498 NAND4X1TS
XU5657 n6953 n7221 n7513 n7518 n7523 NAND4X1TS
XU5658 n6954 n7459 n7464 n7454 n7469 NAND4X1TS
XU5659 n6955 n7474 n7484 n7489 n7479 NAND4X1TS
XU5660 fifo_from_fft_empty_det_N4 n6952 n6953 n6954 n6955 NOR4XLTS
XU5661 n6956 n7419 n7429 n7409 n7414 NAND4X1TS
XU5662 n6957 n7226 n7434 n7439 n7449 NAND4X1TS
XU5663 n6958 n7355 n7360 n7350 n7369 NAND4X1TS
XU5664 n6959 n7379 n7389 n7399 n7384 NAND4X1TS
XU5665 fifo_to_fir_empty_det_N4 n6956 n6957 n6958 n6959 NOR4X1TS
XU5666 n6960 n7310 n7320 n7300 n7305 NAND4X1TS
XU5667 n6961 n7231 n7325 n7330 n7340 NAND4X1TS
XU5668 n6962 n7246 n7251 n7241 n7260 NAND4X1TS
XU5669 n6963 n7270 n7280 n7290 n7275 NAND4X1TS
XU5670 fifo_to_fft_empty_det_N4 n6960 n6961 n6962 n6963 NOR4X1TS
XU5671 n6964 n4132 CLKINVX1TS
XU5672 n6965 n8791 n4026 fifo_to_fir_hang[0] n9473 OAI211X1TS
XU5673 n5569 n4026 fifo_to_fir_hang[0] n6964 n6965 OAI31X1TS
XU5674 n6966 n3957 CLKINVX1TS
XU5675 n6967 n8812 n3851 fifo_to_fft_hang[0] n9477 OAI211X1TS
XU5676 n5517 n3851 fifo_to_fft_hang[0] n6966 n6967 OAI31X1TS
XU5677 n3753 FE_OFN767_n3720 router_data_cntl_data_in[0] FE_OFN756_n3721
+ FE_MDBN3_ FE_OFN746_n3722 fir_data_in[0] AOI222XLTS
XU5678 n3731 FE_OFN773_n3720 router_data_cntl_data_in[22] FE_OFN762_n3721
+ fft_data_in[22] FE_OFN752_n3722 fir_data_in[22] AOI222XLTS
XU5679 n3723 FE_OFN766_n3720 router_data_cntl_data_in[30] FE_OFN756_n3721
+ FE_MDBN13_ FE_OFN745_n3722 fir_data_in[30] AOI222XLTS
XU5680 n6968 n4500 n4542 fifo_from_fft_fifo_cell7_data_out_N35
+ fifo_from_fft_fifo_cell14_data_out_N35 AOI22X1TS
XU5681 n6969 n4518 n4512 fifo_from_fft_fifo_cell11_data_out_N35
+ fifo_from_fft_fifo_cell12_data_out_N35 AOI22X1TS
XU5682 n6970 n4536 n4530 fifo_from_fft_fifo_cell8_data_out_N35
+ fifo_from_fft_fifo_cell9_data_out_N35 AOI22X1TS
XU5683 n6971 n6969 n6970 XOR2X1TS
XU5684 n6972 n6968 n6971 XOR2X1TS
XU5685 n6973 n4506 n4578 fifo_from_fft_fifo_cell1_data_out_N35
+ fifo_from_fft_fifo_cell13_data_out_N35 AOI22X1TS
XU5686 n6974 n4554 n4548 fifo_from_fft_fifo_cell5_data_out_N35
+ fifo_from_fft_fifo_cell6_data_out_N35 AOI22X1TS
XU5687 n6975 n6973 n6974 XOR2X1TS
XU5688 n6976 n4566 n4560 fifo_from_fft_fifo_cell3_data_out_N35
+ fifo_from_fft_fifo_cell4_data_out_N35 AOI22X1TS
XU5689 n6977 n4572 n6976 XOR2X1TS
XU5690 n6978 n6975 n6977 XOR2X1TS
XU5691 n6979 n4494 n4524 fifo_from_fft_fifo_cell10_data_out_N35
+ fifo_from_fft_fifo_cell15_data_out_N35 AOI22X1TS
XU5692 n6980 n6978 n6979 XOR2X1TS
XU5693 n6981 n6972 n6980 XOR2X1TS
XU5694 n4580 fifo_from_fft_fifo_cell15_reg_gtok_token n6981 FE_OFN724_n4643
+ OAI21X1TS
XU5695 n6982 fifo_from_fir_fifo_cell0_controller_valid_read n7217
+ fifo_from_fir_fifo_cell0_controller_write_enable NOR3X1TS
XU5696 fifo_from_fir_fifo_cell0_reg_ptok_N29
+ fifo_from_fir_fifo_cell0_data_out_N35 n3776 n6982 fifo_from_fir_hold[0]
+ AOI31X1TS
XU5697 n3952 fifo_to_fft_hang[0] n8805 n3851 NOR3BX1TS
XU5698 n4127 fifo_to_fir_hang[0] n8784 n4026 NOR3BX1TS
XU5699 add_x_22_2_carry[30] add_x_22_2_carry[29] n7253 NOR2BX1TS
XU5700 router_addr_calc_fir_read_calc_counter_N75 n7253 add_x_22_2_carry[29]
+ XNOR2X1TS
XU5701 n6983 fifo_from_fft_fifo_cell8_controller_valid_read n7490
+ fifo_from_fft_fifo_cell8_controller_write_enable NOR3X1TS
XU5702 n4474 FE_OFN233_n4531 fifo_from_fft_fifo_cell8_data_out_N35 n6983
+ fifo_from_fft_hold[8] AOI31X1TS
XU5703 n6984 fifo_to_fir_fifo_cell5_controller_valid_read n7420
+ fifo_to_fir_fifo_cell5_controller_write_enable NOR3X1TS
XU5704 n4036 n7424 fifo_to_fir_fifo_cell5_data_out_N35 n6984
+ fifo_to_fir_hold[5] AOI31X1TS
XU5705 n6985 fifo_to_fft_fifo_cell11_controller_valid_read n7271
+ fifo_to_fft_fifo_cell11_controller_write_enable NOR3X1TS
XU5706 n3873 n3907 fifo_to_fft_fifo_cell11_data_out_N35 n6985
+ fifo_to_fft_hold[11] AOI31X1TS
XU5707 n6986 fifo_to_fir_fifo_cell12_controller_valid_read n7370
+ fifo_to_fir_fifo_cell12_controller_write_enable NOR3X1TS
XU5708 n4050 n7374 fifo_to_fir_fifo_cell12_data_out_N35 n6986
+ fifo_to_fir_hold[12] AOI31X1TS
XU5709 n6987 fifo_to_fft_fifo_cell13_controller_valid_read n7252
+ fifo_to_fft_fifo_cell13_controller_write_enable NOR3X1TS
XU5710 n3877 fifo_to_fft_fifo_cell13_data_out_N35 n7255 n6987
+ fifo_to_fft_hold[13] AOI31X1TS
XU5711 n6988 fifo_to_fir_fifo_cell14_controller_valid_read n7356
+ fifo_to_fir_fifo_cell14_controller_write_enable NOR3X1TS
XU5712 n4054 fifo_to_fir_fifo_cell14_data_out_N35 n4067 n6988
+ fifo_to_fir_hold[14] AOI31X1TS
XU5713 n6989 n3763 n3764 NOR2X1TS
XU5714 n6990 n3767 n6989 FE_OFN682_n8050 FE_OFN799_n7619 OAI2BB2XLTS
XU5715 n5383 FE_OFN682_n8050 n3760 n9463 n6990 OAI211X1TS
XU5716 n6991 add_x_22_5_carry[31] n7199 XOR2X1TS
XU5717 n6992 FE_OFN939_n3487 n6991 FE_OFN940_n3486 n7198 AOI22X1TS
XU5718 router_addr_calc_iir_write_calc_counter_N209 FE_OFN1295_iir_enable n6992
+ NAND2X1TS
XU5719 n3752 FE_OFN770_n3720 router_data_cntl_data_in[1] FE_OFN759_n3721
+ FE_MDBN4_ FE_OFN749_n3722 fir_data_in[1] AOI222XLTS
XU5720 n3730 FE_OFN772_n3720 router_data_cntl_data_in[23] FE_OFN761_n3721
+ fft_data_in[23] FE_OFN751_n3722 fir_data_in[23] AOI222XLTS
XU5721 n3719 FE_OFN766_n3720 router_data_cntl_data_in[31] n3721 FE_MDBN14_
+ FE_OFN745_n3722 FE_MDBN2_ AOI222XLTS
XU5722 n6993 FE_OFN976_n9462 n9406 router_fir_read_done n3715 AOI31X1TS
XU5723 n4829 FE_OFN839_n7619 from_fir_empty n7603 n6993 NOR4X2TS
XU5724 n6994 n4752 n4746 fifo_from_fir_fifo_cell3_data_out_N35
+ fifo_from_fir_fifo_cell4_data_out_N35 AOI22X1TS
XU5725 n6995 n4740 n4734 fifo_from_fir_fifo_cell5_data_out_N35
+ fifo_from_fir_fifo_cell6_data_out_N35 AOI22X1TS
XU5726 n6996 n4692 n4764 fifo_from_fir_fifo_cell1_data_out_N35
+ fifo_from_fir_fifo_cell13_data_out_N35 AOI22X1TS
XU5727 n6997 n6996 n6995 XOR2X1TS
XU5728 n6998 n4758 n6994 XOR2X1TS
XU5729 n6999 n6997 n6998 XOR2X1TS
XU5730 n7000 n4680 n4710 fifo_from_fir_fifo_cell10_data_out_N35
+ fifo_from_fir_fifo_cell15_data_out_N35 AOI22X1TS
XU5731 n7001 n4704 n4698 fifo_from_fir_fifo_cell11_data_out_N35
+ fifo_from_fir_fifo_cell12_data_out_N35 AOI22X1TS
XU5732 n7002 n4722 n4716 fifo_from_fir_fifo_cell8_data_out_N35
+ fifo_from_fir_fifo_cell9_data_out_N35 AOI22X1TS
XU5733 n7003 n4686 n4728 fifo_from_fir_fifo_cell7_data_out_N35
+ fifo_from_fir_fifo_cell14_data_out_N35 AOI22X1TS
XU5734 n7004 n7001 n7002 XOR2X1TS
XU5735 n7005 n7003 n7004 XOR2X1TS
XU5736 n7006 n6999 n7000 XOR2X1TS
XU5737 n7007 n7005 n7006 XOR2X1TS
XU5738 n4766 fifo_from_fir_fifo_cell15_reg_gtok_token n7007 FE_OFN742_n4829
+ OAI21X1TS
XU5739 n7008 instruction[27] instruction[29] instruction[0] instruction[28]
+ AND4X1TS
XU5740 n7009 n3458 instruction[26] n7008 acc_bypass NAND4BX1TS
XU5741 router_pla_top_N60 n3455 instruction[2] n3456 n7009 AOI211X1TS
XU5742 n7010 n3477 n3476 to_fft_empty OAI21X1TS
XU5743 router_data_cntl_N133 FE_OFN1217_n3478 n9434 n7010 AND3X1TS
XU5744 n7011 fifo_from_fft_fifo_cell0_controller_valid_read n7222
+ fifo_from_fft_fifo_cell0_controller_write_enable NOR3X1TS
XU5745 fifo_from_fft_fifo_cell0_reg_ptok_N29
+ fifo_from_fft_fifo_cell0_data_out_N35 n3796 n7011 fifo_from_fft_hold[0]
+ AOI31X1TS
XU5746 n7012 fifo_to_fir_fifo_cell0_controller_valid_read n7227
+ fifo_to_fir_fifo_cell0_controller_write_enable NOR3X1TS
XU5747 fifo_to_fir_fifo_cell0_reg_ptok_N29 fifo_to_fir_fifo_cell0_data_out_N35
+ n4136 n7012 fifo_to_fir_hold[0] AOI31X1TS
XU5748 n7013 fifo_to_fft_fifo_cell0_controller_valid_read n7232
+ fifo_to_fft_fifo_cell0_controller_write_enable NOR3X1TS
XU5749 fifo_to_fft_fifo_cell0_reg_ptok_N29 fifo_to_fft_fifo_cell0_data_out_N35
+ n3961 n7013 fifo_to_fft_hold[0] AOI31X1TS
XU5774 n7014 router_addr_calc_iir_write_calc_counter_hold CLKINVX2TS
XU5775 n7015 router_addr_calc_N63 INVX2TS
XU5776 n7016 router_addr_calc_N95 INVX2TS
XU5777 n7017 router_addr_calc_N9 INVX1TS
XU5778 n7018 router_addr_calc_N99 INVX2TS
XU5779 n7019 router_addr_calc_fft_write_calc_counter_hold INVX2TS
XU5780 n7020 router_addr_calc_fir_write_calc_counter_hold INVXLTS
XU5781 n7021 router_addr_calc_fft_read_calc_counter_hold INVXLTS
XU5782 n7022 router_addr_calc_fir_read_calc_counter_hold INVX2TS
XU5783 n7023 router_addr_calc_fir_read_calc_counter_hold INVX2TS
XU5787 n521 n2634 n2633 n3840 n3707 NAND4X1TS
XU5795 n7056 n8027 n9384 NOR2BX1TS
XU5796 n7057 n8037 n9384 NOR2BX1TS
XU5797 n7058 n8026 n9384 NOR2BX1TS
XU5798 n7059 n8036 n9384 NOR2BX1TS
XU5799 n7060 n8025 n9385 NOR2BX1TS
XU5800 n7061 n8035 n9385 NOR2BX1TS
XU5801 n7062 n8024 n9385 NOR2BX1TS
XU5802 n7063 n8011 n9385 NOR2BX1TS
XU5803 n7064 n8018 n9381 NOR2BX1TS
XU5804 n7065 n8015 n9381 NOR2BX1TS
XU5805 n7066 n8042 n9381 NOR2BX1TS
XU5806 n7067 n8041 n9382 NOR2BX1TS
XU5807 n7068 n8017 n9382 NOR2BX1TS
XU5808 n7069 n8013 n9382 NOR2BX1TS
XU5809 n7070 n8040 n9382 NOR2BX1TS
XU5810 n7071 n8029 n9383 NOR2BX1TS
XU5811 n7072 n8039 n9383 NOR2BX1TS
XU5812 n7073 n8028 n9383 NOR2BX1TS
XU5813 n7074 n8038 n9383 NOR2BX1TS
XU5814 n7075 n8014 n9381 NOR2BX1TS
XU5815 n7076 n8034 n9386 NOR2BX1TS
XU5816 n7077 n8023 n9386 NOR2BX1TS
XU5817 n7078 n8033 n9386 NOR2BX1TS
XU5818 n7079 n8022 n9386 NOR2BX1TS
XU5819 n7080 n8030 n9388 NOR2BX1TS
XU5820 n7081 n8019 n9388 NOR2BX1TS
XU5821 n7082 n8016 n9388 NOR2BX1TS
XU5822 n7083 n8012 n9388 NOR2BX1TS
XU5823 n7084 n8032 n9387 NOR2BX1TS
XU5824 n7085 n8021 n9387 NOR2BX1TS
XU5825 n7086 n8031 n9387 NOR2BX1TS
XU5826 n7087 n8020 n9387 NOR2BX1TS
XU5827 n8715 FE_OFN174_n8054 INVX1TS
XU5828 n8716 FE_OFN174_n8054 INVX1TS
XU5829 n8713 FE_OFN173_n8054 CLKINVX2TS
XU5830 n8717 FE_OFN174_n8054 INVX1TS
XU5831 n8718 n8054 INVX1TS
XU5832 n8714 FE_OFN174_n8054 CLKINVX2TS
XU5833 n8712 FE_OFN173_n8054 CLKINVX2TS
XU5834 n8378 FE_OFN509_n8055 INVX1TS
XU5835 n8379 FE_OFN510_n8055 INVX1TS
XU5836 n8382 FE_OFN510_n8055 INVX1TS
XU5837 n8384 FE_OFN508_n8055 INVX1TS
XU5838 n8381 FE_OFN510_n8055 INVX1TS
XU5839 n8383 FE_OFN508_n8055 INVX1TS
XU5840 n8380 FE_OFN510_n8055 INVX1TS
XU5841 n8719 FE_OFN173_n8054 INVXLTS
XU5842 n8377 FE_OFN509_n8055 INVX1TS
XU5843 n7366 n4072 INVX1TS
XU5844 n7256 n3897 INVX1TS
XU5845 n7255 n3897 INVX2TS
XU5846 n7365 n4072 INVX2TS
XU5847 n7374 n4077 INVX2TS
XU5848 n7265 n3902 INVX2TS
XU5849 n7286 n3917 CLKINVX1TS
XU5850 n7395 n4092 CLKINVX1TS
XU5851 n7394 n4092 INVX2TS
XU5852 n7285 n3917 INVX2TS
XU5853 n7295 n3922 INVX2TS
XU5854 n7404 n4097 INVX2TS
XU5855 n7315 n3937 INVX2TS
XU5856 n7424 n4112 INVX2TS
XU5857 n7316 n3937 CLKINVX1TS
XU5858 n7425 n4112 CLKINVX1TS
XU5859 n8143 FE_OFN665_n8053 INVX1TS
XU5860 n8144 n8053 INVX1TS
XU5861 n8141 FE_OFN665_n8053 INVX1TS
XU5862 n8140 FE_OFN665_n8053 CLKINVX2TS
XU5863 n8142 FE_OFN665_n8053 INVX1TS
XU5864 n8139 FE_OFN664_n8053 CLKINVX2TS
XU5865 n8473 FE_OFN326_n8056 INVX1TS
XU5866 n8474 FE_OFN326_n8056 INVX1TS
XU5867 n8480 FE_OFN326_n8056 INVX1TS
XU5868 n8479 FE_OFN326_n8056 INVX1TS
XU5869 n8475 FE_OFN325_n8056 INVX1TS
XU5870 n8478 FE_OFN325_n8056 INVX1TS
XU5871 n8476 FE_OFN325_n8056 INVX1TS
XU5872 n8138 FE_OFN664_n8053 CLKINVX2TS
XU5873 n8477 n8056 INVX1TS
XU5874 n8145 n8053 CLKINVX1TS
XU5875 n8790 n8057 INVX1TS
XU5876 n8789 FE_OFN734_n8057 CLKINVX2TS
XU5877 n8787 FE_OFN733_n8057 INVX1TS
XU5878 n8876 FE_OFN679_n8050 CLKINVX1TS
XU5879 n8843 n8052 CLKINVX1TS
XU5880 n8811 FE_OFN731_n8058 INVX1TS
XU5881 n7444 n4128 INVX2TS
XU5882 n8808 FE_OFN729_n8058 INVX1TS
XU5883 n8842 FE_OFN697_n8052 CLKINVX1TS
XU5884 n7335 n3953 INVX2TS
XU5885 n8810 FE_OFN730_n8058 CLKINVX2TS
XU5886 n8875 FE_OFN679_n8050 CLKINVX1TS
XU5887 n7445 n4128 CLKINVX1TS
XU5888 n7236 n3883 CLKINVX2TS
XU5889 n7616 n4057 INVX1TS
XU5890 n7615 n4057 INVX1TS
XU5891 n7614 n4057 INVX1TS
XU5892 n8845 FE_OFN698_n8052 INVXLTS
XU5893 n8057 n3715 router_fir_put_req_reg n9465 n7608 AND4X1TS
XU5894 n8873 FE_OFN680_n8050 CLKINVX1TS
XU5895 n8878 FE_OFN682_n8050 INVXLTS
XU5896 n7617 n4057 INVX1TS
XU5897 n7336 n3953 CLKINVX1TS
XU5898 n8840 FE_OFN696_n8052 CLKINVX1TS
XU5899 n7345 n4058 CLKINVX2TS
XU5900 n7608 n3474 INVX2TS
XU5901 n8870 n8050 INVX1TS
XU5902 n8837 n8052 INVX1TS
XU5903 n8841 FE_OFN697_n8052 CLKINVX1TS
XU5904 n8874 FE_OFN680_n8050 CLKINVX1TS
XU5905 n9378 FE_OFN718_n8051 CLKINVX1TS
XU5906 n4057 FE_OFN800_n7619 FE_OFN687_n4134 OR2X2TS
XU5907 n9372 FE_OFN717_n8051 CLKINVX2TS
XU5908 n9376 FE_OFN718_n8051 CLKINVX2TS
XU5909 n9370 n8051 CLKINVX2TS
XU5910 n9377 FE_OFN718_n8051 CLKINVX2TS
XU5911 n9371 n8051 CLKINVX2TS
XU5912 n9373 FE_OFN717_n8051 CLKINVX2TS
XU5913 n9375 FE_OFN718_n8051 CLKINVX1TS
XU5914 n9374 FE_OFN717_n8051 CLKINVX1TS
XU5915 n7971 n7967 INVX1TS
XU5916 n7970 n7967 INVX1TS
XU5917 n5580 FE_OFN711_n4207 mips_mips_accfullinstruction[25] CLKAND2X2TS
XU5918 n7968 n7967 INVX1TS
XU5919 n5581 FE_OFN710_n4207 mips_mips_accfullinstruction[24] CLKAND2X2TS
XU5920 n5582 FE_OFN713_n4207 mips_mips_accfullinstruction[23] CLKAND2X2TS
XU5921 n5583 FE_OFN711_n4207 mips_mips_accfullinstruction[22] CLKAND2X2TS
XU5922 n7969 n7967 INVX1TS
XU5923 n8051 mips_mips_a_countflag mips_mips_a_N49 OR2X2TS
XU5924 n7965 n7962 INVX1TS
XU5925 n7964 n7962 INVX1TS
XU5926 n7963 n7962 INVX1TS
XU5927 n7966 n7962 INVX1TS
XU5928 n7593 n4756 INVX2TS
XU5929 n7490 n4534 CLKINVX2TS
XU5930 n7369 n4076 INVX2TS
XU5931 n7568 n4726 INVX2TS
XU5932 n7280 n3916 INVX2TS
XU5933 n7514 n4564 CLKINVX2TS
XU5934 n7232 n3820 CLKINVX2TS
XU5935 n7470 n4510 CLKINVX1TS
XU5936 n7414 n4106 INVX2TS
XU5937 n7464 n4504 INVX2TS
XU5938 n5600 FE_OFN711_n4207 mips_mips_accfullinstruction[5] CLKAND2X2TS
XU5939 n7409 n4101 INVX2TS
XU5940 n7563 n4720 INVX2TS
XU5941 n7270 n3906 INVX2TS
XU5942 n7493 n4540 INVX2TS
XU5943 n7484 n4528 INVX2TS
XU5944 n7356 n4066 CLKINVX1TS
XU5945 n7553 n4708 INVX2TS
XU5946 n7275 n3911 INVX2TS
XU5947 n7558 n4714 INVX2TS
XU5948 n7379 n4081 INVX2TS
XU5949 n7459 n4498 INVX2TS
XU5950 n7480 n4522 CLKINVX1TS
XU5951 n7548 n4702 INVX2TS
XU5952 n7260 n3901 INVX2TS
XU5953 n7399 n4096 INVX2TS
XU5954 n7361 n4071 CLKINVX1TS
XU5955 n7384 n4086 INVX2TS
XU5956 n7370 n4076 CLKINVX2TS
XU5957 n7242 n3886 CLKINVX1TS
XU5958 n7251 n3896 INVX2TS
XU5959 n7252 n3896 INVX1TS
XU5960 n7594 n4756 CLKINVX1TS
XU5961 n7469 n4510 INVX2TS
XU5962 n7380 n4081 CLKINVX2TS
XU5963 n7573 n4732 INVX2TS
XU5964 n5579 n7977 mips_mips_accfullinstruction[26] CLKAND2X2TS
XU5965 n7321 n3941 CLKINVX1TS
XU5966 n7261 n3901 CLKINVX2TS
XU5967 n7598 n4762 INVX2TS
XU5968 n7216 n3774 INVX2TS
XU5969 n7385 n4086 CLKINVX2TS
XU5970 n7311 n3936 INVX1TS
XU5971 n7246 n3891 INVX2TS
XU5972 n7430 n4116 CLKINVX1TS
XU5973 n7538 n4690 INVX2TS
XU5974 n7474 n4516 INVX2TS
XU5975 n7271 n3906 CLKINVX2TS
XU5976 n7533 n4684 INVX2TS
XU5977 n7241 n3886 INVX2TS
XU5978 n7390 n4091 CLKINVX2TS
XU5979 n5577 n7977 mips_mips_accfullinstruction[28] CLKAND2X2TS
XU5980 n7301 n3926 INVX2TS
XU5981 n7485 n4528 INVX1TS
XU5982 n7420 n4111 INVX1TS
XU5983 n7543 n4696 INVX2TS
XU5984 n7489 n4534 INVX2TS
XU5985 n7389 n4091 INVX2TS
XU5986 n7291 n3921 CLKINVX2TS
XU5987 n7276 n3911 INVX2TS
XU5988 n7400 n4096 CLKINVX2TS
XU5989 n7415 n4106 CLKINVX2TS
XU5990 n7281 n3916 INVX2TS
XU5991 n7410 n4101 CLKINVX2TS
XU5992 n5578 n7977 mips_mips_accfullinstruction[27] CLKAND2X2TS
XU5993 n7330 n3951 INVX2TS
XU5994 n7226 n3809 INVX2TS
XU5995 n7325 n3946 INVX2TS
XU5996 n7449 n4131 INVX2TS
XU5997 n7429 n4116 INVX2TS
XU5998 n7340 n3956 INVX2TS
XU5999 n7574 n4732 CLKINVX2TS
XU6000 n7498 n4546 INVX2TS
XU6001 n7231 n3820 INVX2TS
XU6002 n7569 n4726 CLKINVX2TS
XU6003 n7588 n4750 INVX2TS
XU6004 n7320 n3941 INVX2TS
XU6005 n7503 n4552 INVX2TS
XU6006 n7475 n4516 CLKINVX1TS
XU6007 n7554 n4708 CLKINVX1TS
XU6008 n7310 n3936 INVX2TS
XU6009 n7583 n4744 INVX2TS
XU6010 n7564 n4720 CLKINVX2TS
XU6011 n7439 n4126 INVX2TS
XU6012 n7454 n4492 INVX2TS
XU6013 n7579 n4738 CLKINVX2TS
XU6014 n7227 n3809 CLKINVX2TS
XU6015 n7528 n4678 INVX2TS
XU6016 n7509 n4558 CLKINVX2TS
XU6017 n7247 n3891 CLKINVX1TS
XU6018 n7559 n4714 CLKINVX1TS
XU6019 n7513 n4564 INVX2TS
XU6020 n7544 n4696 CLKINVX1TS
XU6021 n7504 n4552 CLKINVX2TS
XU6022 n7434 n4121 INVX2TS
XU6023 n7419 n4111 INVX2TS
XU6024 n7508 n4558 INVX2TS
XU6025 n7355 n4066 INVX2TS
XU6026 n7479 n4522 INVX2TS
XU6027 n7584 n4744 CLKINVX2TS
XU6028 n7578 n4738 INVX2TS
XU6029 n7549 n4702 CLKINVX1TS
XU6030 n7499 n4546 CLKINVX2TS
XU6031 n7290 n3921 INVX2TS
XU6032 n7589 n4750 INVX1TS
XU6033 n7300 n3926 INVX2TS
XU6034 n7360 n4071 CLKINVX2TS
XU6035 n7494 n4540 CLKINVX2TS
XU6036 n7203 FE_OFN973_n7207 INVX2TS
XU6037 n7977 n3456 INVX1TS
XU6038 n7306 n3931 CLKINVX2TS
XU6039 n7351 n4061 CLKINVX1TS
XU6040 n7305 n3931 INVX2TS
XU6041 n5576 n4205 mips_mips_accfullinstruction[29] AND2XLTS
XU6042 n5574 n4205 mips_mips_accfullinstruction[31] AND2XLTS
XU6043 n5575 n4205 mips_mips_accfullinstruction[30] AND2XLTS
XU6044 n7518 n4570 INVX2TS
XU6045 n7524 n4576 CLKINVX1TS
XU6046 n7221 n3794 INVX2TS
XU6047 n9463 FE_OFN793_n7619 CLKINVX2TS
XU6048 n9545 FE_OFN807_n7619 CLKINVX2TS
XU6049 n9464 FE_OFN789_n7619 CLKINVX2TS
XU6050 n9546 FE_OFN785_n7619 CLKINVX2TS
XU6051 n9543 FE_OFN815_n7619 CLKINVX2TS
XU6052 n7519 n4570 INVX1TS
XU6053 n9544 FE_OFN812_n7619 CLKINVX2TS
XU6054 n7350 n4061 INVX2TS
XU6055 n7523 n4576 INVX2TS
XU6056 n9525 FE_OFN811_n7619 CLKINVX2TS
XU6057 n9521 FE_OFN832_n7619 CLKINVX2TS
XU6058 n9509 FE_OFN795_n7619 CLKINVX2TS
XU6059 n9528 FE_OFN821_n7619 CLKINVX2TS
XU6060 n9508 FE_OFN796_n7619 CLKINVX2TS
XU6061 n9488 FE_OFN799_n7619 CLKINVX2TS
XU6062 n9516 FE_OFN790_n7619 CLKINVX2TS
XU6063 n9520 FE_OFN791_n7619 CLKINVX2TS
XU6064 n9522 FE_OFN824_n7619 CLKINVX2TS
XU6065 n9524 FE_OFN787_n7619 CLKINVX2TS
XU6066 n9517 FE_OFN826_n7619 CLKINVX2TS
XU6067 n9547 FE_OFN784_n7619 CLKINVX2TS
XU6068 n9531 FE_OFN778_n7619 CLKINVX2TS
XU6069 n9493 FE_OFN811_n7619 CLKINVX2TS
XU6070 n9512 FE_OFN815_n7619 CLKINVX2TS
XU6071 n9530 FE_OFN822_n7619 CLKINVX2TS
XU6072 n9510 FE_OFN795_n7619 CLKINVX2TS
XU6073 n9529 FE_OFN808_n7619 CLKINVX2TS
XU6074 n9526 FE_OFN816_n7619 CLKINVX2TS
XU6075 n9515 FE_OFN784_n7619 CLKINVX2TS
XU6076 n9511 FE_OFN793_n7619 CLKINVX2TS
XU6077 n9518 FE_OFN842_n7619 CLKINVX2TS
XU6078 n9479 FE_OFN813_n7619 CLKINVX2TS
XU6079 n9478 FE_OFN797_n7619 CLKINVX2TS
XU6080 n9495 FE_OFN810_n7619 CLKINVX2TS
XU6081 n9474 FE_OFN790_n7619 CLKINVX2TS
XU6082 n9519 FE_OFN792_n7619 CLKINVX2TS
XU6083 n9491 FE_OFN801_n7619 CLKINVX2TS
XU6084 n9523 FE_OFN802_n7619 CLKINVX2TS
XU6085 n9492 FE_OFN777_n7619 CLKINVX2TS
XU6086 n9477 FE_OFN797_n7619 CLKINVX2TS
XU6087 n9527 FE_OFN814_n7619 CLKINVX2TS
XU6088 n9489 FE_OFN786_n7619 CLKINVX2TS
XU6089 n7606 n8059 CLKINVX2TS
XU6090 n7207 n3472 INVX2TS
XU6091 n9501 FE_OFN798_n7619 CLKINVX2TS
XU6092 n9539 FE_OFN781_n7619 CLKINVX2TS
XU6093 n9502 FE_OFN814_n7619 CLKINVX2TS
XU6094 n9540 FE_OFN818_n7619 CLKINVX2TS
XU6095 n9541 FE_OFN830_n7619 CLKINVX2TS
XU6096 n9535 FE_OFN800_n7619 CLKINVX2TS
XU6097 n9467 FE_OFN831_n7619 CLKINVX2TS
XU6098 n9500 FE_OFN805_n7619 CLKINVX2TS
XU6099 n9466 FE_OFN833_n7619 CLKINVX2TS
XU6100 n9507 FE_OFN830_n7619 CLKINVX2TS
XU6101 n9542 FE_OFN783_n7619 CLKINVX2TS
XU6102 n9503 FE_OFN823_n7619 CLKINVX2TS
XU6103 n9471 FE_OFN827_n7619 CLKINVX2TS
XU6104 n9468 FE_OFN815_n7619 CLKINVX2TS
XU6105 n9532 FE_OFN834_n7619 CLKINVX2TS
XU6106 n9533 FE_OFN826_n7619 CLKINVX2TS
XU6107 n9534 FE_OFN819_n7619 CLKINVX2TS
XU6108 n9506 FE_OFN780_n7619 CLKINVX2TS
XU6109 n9505 FE_OFN793_n7619 CLKINVX2TS
XU6110 n9504 FE_OFN777_n7619 CLKINVX2TS
XU6111 n9496 FE_OFN834_n7619 CLKINVX2TS
XU6112 n9498 FE_OFN801_n7619 CLKINVX2TS
XU6113 n9499 FE_OFN838_n7619 CLKINVX2TS
XU6114 n9434 FE_OFN974_n9462 CLKINVX1TS
XU6115 n9415 FE_OFN993_n9431 CLKINVX2TS
XU6116 n9442 FE_OFN982_n9462 CLKINVX2TS
XU6117 fft_enable FE_OFN983_n9462 CLKINVX4TS
XU6118 n9414 FE_OFN987_n9431 CLKINVX2TS
XU6119 n8059 FE_OFN979_n9462 FE_OFN991_n9431 FE_OFN1286_iir_enable NAND3XLTS
XU6120 n7610 FE_OFN1285_router_ram_read_enable_reg INVX2TS
XU6121 n9443 FE_OFN982_n9462 CLKINVX1TS
XU6122 n9439 FE_OFN975_n9462 CLKINVX1TS
XU6123 n9445 FE_OFN983_n9462 INVX1TS
XU6124 n7611 FE_OFN1285_router_ram_read_enable_reg CLKINVX2TS
XU6125 n9440 FE_OFN975_n9462 CLKINVX1TS
XU6126 n9444 FE_OFN983_n9462 INVX1TS
XU6127 n9391 iir_enable INVXLTS
XU6128 n9447 FE_OFN984_n9462 CLKINVX2TS
XU6129 n9420 FE_OFN992_n9431 CLKINVX2TS
XU6130 n9417 FE_OFN993_n9431 CLKINVX1TS
XU6131 n9416 FE_OFN992_n9431 CLKINVX1TS
XU6132 n7603 router_fir_get_req_reg INVX2TS
XU6133 n9421 FE_OFN992_n9431 CLKINVX2TS
XU6134 n7211 router_fir_read_done INVX2TS
XU6135 n9446 FE_OFN984_n9462 CLKINVX2TS
XU6136 n9470 FE_OFN812_n7619 CLKINVX2TS
XU6137 n7960 n4458 CLKINVX1TS
XU6138 n7527 n7525 INVX1TS
XU6139 n7157 n7155 CLKINVX1TS
XU6140 n7151 n7149 CLKINVX1TS
XU6141 n7162 n7161 CLKINVX1TS
XU6142 n7403 n7401 INVX1TS
XU6144 n7393 n7391 INVX1TS
XU6145 n7398 n7396 CLKINVX2TS
XU6146 n7378 n7376 CLKINVX1TS
XU6147 n7502 n7500 CLKINVX1TS
XU6148 n7166 n7164 INVX1TS
XU6149 n7154 n7152 INVX1TS
XU6150 n7160 n7158 CLKINVX2TS
XU6151 n7130 n7128 CLKINVX1TS
XU6152 n7373 n7371 CLKINVX1TS
XU6153 n7497 n7495 CLKINVX1TS
XU6154 n7168 n7167 CLKINVX1TS
XU6155 n7147 n7146 CLKINVX1TS
XU6156 n7387 n7386 CLKINVX1TS
XU6157 n7511 n7510 CLKINVX1TS
XU6158 n7192 n7191 CLKINVX2TS
XU6159 n7174 n7173 CLKINVX1TS
XU6160 n7186 n7185 INVX1TS
XU6161 n7141 n7140 CLKINVX1TS
XU6162 n7382 n7381 CLKINVX1TS
XU6163 n7506 n7505 CLKINVX1TS
XU6165 n7199 n7197 CLKINVX1TS
XU6166 n7136 n7134 CLKINVX1TS
XU6167 n7442 n7441 CLKINVX1TS
XU6168 n7189 n7188 CLKINVX1TS
XU6169 n7224 n7223 CLKINVX1TS
XU6170 n7522 n7520 CLKINVX2TS
XU6171 n7089 n7088 CLKINVX1TS
XU6172 n7422 n7421 CLKINVX1TS
XU6173 n7546 n7545 CLKINVX1TS
XU6174 n7132 n7131 CLKINVX1TS
XU6175 n7183 n7182 CLKINVX1TS
XU6176 n7541 n7540 CLKINVX1TS
XU6177 n7096 n7094 CLKINVX1TS
XU6178 n7591 n7590 CLKINVX1TS
XU6179 n7417 n7416 CLKINVX1TS
XU6180 n7472 n7471 CLKINVX1TS
XU6181 n7138 n7137 CLKINVX1TS
XU6182 n7234 n7233 CLKINVX1TS
XU6183 n7177 n7176 CLKINVX1TS
XU6184 n7101 n7100 CLKINVX1TS
XU6185 n7596 n7595 CLKINVX1TS
XU6186 n7412 n7411 CLKINVX1TS
XU6187 n7477 n7476 CLKINVX1TS
XU6188 n7536 n7535 CLKINVX1TS
XU6189 n7145 n7143 CLKINVX1TS
XU6190 n7566 n7565 CLKINVX1TS
XU6191 n7289 n7287 INVX1TS
XU6192 n7109 n7108 CLKINVX1TS
XU6193 n7309 n7307 CLKINVX1TS
XU6194 n7209 n7208 CLKINVX1TS
XU6195 n7304 n7302 CLKINVX1TS
XU6196 n7205 n7204 CLKINVX1TS
XU6197 n7104 n7103 CLKINVX1TS
XU6198 n7258 n7257 INVX2TS
XU6199 n7263 n7262 CLKINVX2TS
XU6200 n7437 n7436 CLKINVX1TS
XU6201 n7561 n7560 CLKINVX1TS
XU6202 n7329 n7327 CLKINVX1TS
XU6203 n7115 n7114 CLKINVX1TS
XU6204 n7571 n7570 CLKINVX1TS
XU6205 n7201 n7200 CLKINVX1TS
XU6206 n7447 n7446 CLKINVX1TS
XU6207 n7318 n7317 CLKINVX1TS
XU6208 n7359 n7357 CLKINVX1TS
XU6209 n7517 n7515 INVX1TS
XU6210 n7432 n7431 CLKINVX1TS
XU6211 n7214 n7213 CLKINVX1TS
XU6212 n7354 n7352 CLKINVX1TS
XU6213 n7556 n7555 CLKINVX1TS
XU6214 n7098 n7097 CLKINVX1TS
XU6215 n7279 n7277 INVX1TS
XU6216 n7284 n7282 CLKINVX2TS
XU6217 n7334 n7332 CLKINVX1TS
XU6218 n7576 n7575 CLKINVX1TS
XU6219 n7121 n7120 CLKINVX1TS
XU6220 n7324 n7322 CLKINVX1TS
XU6221 n7299 n7297 CLKINVX1TS
XU6222 n7452 n7451 CLKINVX1TS
XU6223 n7338 n7337 CLKINVX1TS
XU6224 n7195 n7194 CLKINVX1TS
XU6225 n7219 n7218 CLKINVX1TS
XU6226 n7313 n7312 CLKINVX1TS
XU6227 n7427 n7426 CLKINVX1TS
XU6228 n7092 n7091 CLKINVX1TS
XU6229 n7269 n7267 INVX1TS
XU6230 n7581 n7580 CLKINVX1TS
XU6231 n7551 n7550 CLKINVX1TS
XU6232 n7274 n7272 INVX1TS
XU6233 n7457 n7456 CLKINVX1TS
XU6234 n7126 n7125 CLKINVX1TS
XU6235 n7343 n7342 CLKINVX1TS
XU6236 n7408 n7406 CLKINVX1TS
XU6237 n7239 n7238 CLKINVX1TS
XU6238 n7172 n7170 CLKINVX1TS
XU6239 n7113 n7111 CLKINVX1TS
XU6240 n7532 n7530 CLKINVX1TS
XU6241 n7294 n7292 CLKINVX1TS
XU6242 n7180 n7179 INVX1TS
XU6243 n1161 fifo_from_fft_fifo_cell9_data_out_N9 INVX2TS
XU6244 n2569 fifo_from_fir_fifo_cell15_data_out_N9 INVX2TS
XU6245 n1289 fifo_from_fft_fifo_cell11_data_out_N9 INVX2TS
XU6246 n1353 fifo_from_fft_fifo_cell12_data_out_N9 INVX2TS
XU6247 n2441 fifo_from_fir_fifo_cell13_data_out_N9 INVX2TS
XU6248 n1417 fifo_from_fft_fifo_cell13_data_out_N9 INVX2TS
XU6249 n2377 fifo_from_fir_fifo_cell12_data_out_N9 INVX2TS
XU6250 n1225 fifo_from_fft_fifo_cell10_data_out_N9 INVX2TS
XU6251 n1097 fifo_from_fft_fifo_cell8_data_out_N9 INVX2TS
XU6252 n2505 fifo_from_fir_fifo_cell14_data_out_N9 INVX2TS
XU6253 n2313 fifo_from_fir_fifo_cell11_data_out_N9 INVX2TS
XU6254 n585 fifo_from_fft_fifo_cell0_data_out_N9 INVX1TS
XU6255 n1481 fifo_from_fft_fifo_cell14_data_out_N9 INVX2TS
XU6256 n1673 fifo_from_fir_fifo_cell1_data_out_N9 INVX2TS
XU6257 n1033 fifo_from_fft_fifo_cell7_data_out_N9 INVX2TS
XU6258 n2249 fifo_from_fir_fifo_cell10_data_out_N9 INVX2TS
XU6259 n649 fifo_from_fft_fifo_cell1_data_out_N9 INVX2TS
XU6260 n1609 fifo_from_fir_fifo_cell0_data_out_N9 INVX1TS
XU6261 n1737 fifo_from_fir_fifo_cell2_data_out_N9 INVX2TS
XU6262 n1545 fifo_from_fft_fifo_cell15_data_out_N9 INVX2TS
XU6263 n969 fifo_from_fft_fifo_cell6_data_out_N9 INVX2TS
XU6264 n2185 fifo_from_fir_fifo_cell9_data_out_N9 INVX2TS
XU6265 n713 fifo_from_fft_fifo_cell2_data_out_N9 INVX2TS
XU6266 n1801 fifo_from_fir_fifo_cell3_data_out_N9 INVX2TS
XU6267 n905 fifo_from_fft_fifo_cell5_data_out_N9 INVX2TS
XU6268 n1865 fifo_from_fir_fifo_cell4_data_out_N9 INVX2TS
XU6269 n2121 fifo_from_fir_fifo_cell8_data_out_N9 INVX2TS
XU6270 n1929 fifo_from_fir_fifo_cell5_data_out_N9 INVX2TS
XU6271 n841 fifo_from_fft_fifo_cell4_data_out_N9 INVX2TS
XU6272 n2057 fifo_from_fir_fifo_cell7_data_out_N9 INVX2TS
XU6273 n777 fifo_from_fft_fifo_cell3_data_out_N9 INVX2TS
XU6275 n1993 fifo_from_fir_fifo_cell6_data_out_N9 INVX2TS
XU6277 n137 router_addr_calc_N191 INVX2TS
XU6278 n9431 n9615 INVX2TS
XU6279 n9462 n9614 INVX2TS
XU6538 n7119 n7117 INVXLTS
XU6539 n7212 router_fir_read_done INVXLTS
XU6540 n7217 n3774 INVXLTS
XU6541 n7222 n3794 INVXLTS
XU6542 n7230 n7228 INVXLTS
XU6543 n7237 n3883 INVXLTS
XU6544 n7245 n7243 INVXLTS
XU6545 n7250 n7248 CLKINVX2TS
XU6546 n7266 n3902 INVXLTS
XU6548 n7326 n3946 INVXLTS
XU6549 n7331 n3951 INVXLTS
XU6550 n7341 n3956 INVXLTS
XU6551 n7346 n4058 INVXLTS
XU6552 n7349 n7347 CLKINVX2TS
XU6553 n7364 n7362 CLKINVX2TS
XU6554 n7375 n4077 INVXLTS
XU6555 n7405 n4097 INVXLTS
XU6556 n7435 n4121 INVXLTS
XU6557 n7440 n4126 INVXLTS
XU6558 n7450 n4131 INVXLTS
XU6559 n7455 n4492 INVXLTS
XU6560 n7460 n4498 INVXLTS
XU6561 n7463 n7461 INVXLTS
XU6562 n7465 n4504 INVXLTS
XU6563 n7468 n7466 INVXLTS
XU6564 n7483 n7481 CLKINVX2TS
XU6565 n7488 n7486 INVXLTS
XU6566 n7529 n4678 INVXLTS
XU6567 n7534 n4684 INVXLTS
XU6568 n7539 n4690 INVXLTS
XU6569 n7587 n7585 INVXLTS
XU6570 n7599 n4762 INVXLTS
XU6571 n7602 n7600 INVXLTS
XU6572 n7607 n8059 INVXLTS
XU6573 n7609 n3474 INVXLTS
XU6574 n7618 FE_OFN1447_reset INVX2TS
XU6575 n7619 n7618 INVX2TS
XU6576 n8050 FE_OFN1451_acc_fir_put n9514 n3465 AND3X2TS
XU6577 n8052 FE_OFN1449_acc_fft_put n9513 n3477 AND3X2TS
XU6651 n7953 n4025 INVX2TS
XU6653 n7962 FE_OFN828_n7619 FE_OFN741_n4829 OR2X2TS
XU6654 n7967 FE_OFN847_n7619 FE_OFN728_n4643 OR2X2TS
XU6655 n7973 n7972 INVX2TS
XU6656 n7976 n7972 INVX2TS
XU6657 n7975 n7972 INVX2TS
XU6658 n7974 n7972 INVX2TS
XU6659 router_addr_calc_fft_read_calc_counter_N77 add_x_22_0_carry[31] n7488
+ XOR2X1TS
XU6661 router_addr_calc_fft_write_calc_counter_N77 add_x_22_1_carry[31]
+ router_addr_calc_fft_write_calc_count[31] XOR2X1TS
XU6663 router_addr_calc_fir_read_calc_counter_N77 add_x_22_2_carry[31] n7250
+ XOR2X1TS
XU6665 router_addr_calc_fir_write_calc_counter_N77 add_x_22_3_carry[31] n7119
+ XOR2X1TS
XU6684 n8872 FE_OFN680_n8050 INVX2TS
XU6689 n8839 FE_OFN697_n8052 INVX2TS
XU6741 n9537 FE_OFN785_n7619 INVX2TS
XU6742 n9536 FE_OFN779_n7619 INVX2TS
XU6743 n9538 FE_OFN781_n7619 INVX2TS
XU6744 n9390 iir_enable INVX2TS
XU6745 n9389 FE_OFN1286_iir_enable INVX2TS
XU6766 fir_enable FE_OFN986_n9431 INVX2TS
XU6777 n9475 FE_OFN816_n7619 INVX2TS
XU6778 n8809 FE_OFN731_n8058 INVX2TS
XU6779 n8788 FE_OFN734_n8057 INVX2TS
XU6782 n9476 FE_OFN819_n7619 INVX2TS
XU6785 n8791 FE_OFN732_n8057 INVX2TS
XU6786 n8812 FE_OFN730_n8058 INVX2TS
XU6790 n9472 FE_OFN789_n7619 INVX2TS
XU6791 n9469 FE_OFN799_n7619 INVX2TS
XU6792 n9473 FE_OFN777_n7619 INVX2TS
XU6793 n5603 n4207 mips_mips_accfullinstruction[2] AND2X2TS
XU6794 n5602 FE_OFN709_n4207 mips_mips_accfullinstruction[3] AND2X2TS
XU6811 n9448 FE_OFN984_n9462 INVX2TS
XU6812 n9413 FE_OFN989_n9431 INVX2TS
XU6813 n9449 FE_OFN984_n9462 INVX2TS
XU6822 n9490 FE_OFN842_n7619 INVX2TS
XU6823 n9494 FE_OFN823_n7619 INVX2TS
XU6841 n9484 FE_OFN809_n7619 INVX2TS
XU6842 n9483 FE_OFN806_n7619 INVX2TS
XU6843 n9482 FE_OFN824_n7619 INVX2TS
XU6844 n9481 FE_OFN825_n7619 INVX2TS
XU6845 n6233 n3754 n3843 n3841 n3755 OAI22XLTS
XU6847 n9438 FE_OFN975_n9462 INVX2TS
XU6848 n9419 FE_OFN993_n9431 INVX2TS
XU6851 n9437 FE_OFN980_n9462 INVX2TS
XU6852 n9436 FE_OFN980_n9462 INVX2TS
XU6855 n9418 FE_OFN993_n9431 INVX2TS
XU6856 n9441 FE_OFN975_n9462 INVX2TS
XU6871 n9487 FE_OFN788_n7619 INVX2TS
XU6872 n9486 FE_OFN817_n7619 INVX2TS
.ENDS
.GLOBAL VDD
.GLOBAL VSS
